File: ECAD/EPS/Boost-BuckMPPT.kicad_sch (KiCad schematic)
At the start: 33 parts, among them Q6 Si4186DY, U21 LM358, U22 INA180A3, U23 INA180A3, U24 LT3652EMSE, U25 LMC555xM

Commit message: respec and consolidate
Parts:
- L3: value 22uH -> 10uH; footprint Inductor_SMD:L_Bourns_SRP7028A_7.3x6.6mm -> Inductor_SMD:L_AVX_LMLP07A7
- L4: value 47uH -> 10uH; footprint Inductor_SMD:L_Bourns_SRR1260 -> Inductor_SMD:L_AVX_LMLP07A7
- renumbered D17 to D21, D18 to D22, D19 to D23, R40 to R39, R39 to R40
Changed lines of the file:
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@@
     (in_bom yes) (on_board yes)
     (property "Reference" "L4" (id 0) (at 161.29 30.734 90))
-    (property "Value" "47uH" (id 1) (at 161.29 33.0454 90))
-    (property "Footprint" "Inductor_SMD:L_Bourns_SRR1260" (id 2) (at 161.29 35.56 0)
+    (property "Value" "10uH" (id 1) (at 161.29 33.0454 90))
+    (property "Footprint" "Inductor_SMD:L_AVX_LMLP07A7" (id 2) (at 161.29 35.56 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:D_Schottky") (at 176.53 35.56 180) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "D19" (id 0) (at 176.53 30.0482 0))
+    (property "Reference" "D23" (id 0) (at 176.53 30.0482 0))
     (property "Value" "CMSH3-40MA" (id 1) (at 176.53 32.3596 0))
     (property "Footprint" "Diode_SMD:D_SMA" (id 2) (at 176.53 35.56 0)
@@
   (symbol (lib_id "power:GND") (at 139.7 66.04 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR075" (id 0) (at 139.7 72.39 0)
+    (property "Reference" "#PWR077" (id 0) (at 139.7 72.39 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:R") (at 50.8 101.6 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "R40" (id 0) (at 52.07 101.6 0)
+    (property "Reference" "R39" (id 0) (at 52.07 101.6 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Device:R") (at 50.8 121.92 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "R39" (id 0) (at 52.07 121.92 0)
+    (property "Reference" "R40" (id 0) (at 52.07 121.92 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "power:GND") (at 50.8 127 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR073" (id 0) (at 50.8 133.35 0)
+    (property "Reference" "#PWR075" (id 0) (at 50.8 133.35 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:D_Schottky") (at 124.46 106.68 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "D18" (id 0) (at 124.46 101.1682 0))
+    (property "Reference" "D22" (id 0) (at 124.46 101.1682 0))
     (property "Value" "RB051MM-2Y" (id 1) (at 124.46 103.4796 0))
     (property "Footprint" "Diode_SMD:D_SOD-123F" (id 2) (at 124.46 106.68 0)
@@
   (symbol (lib_id "Device:D_Schottky") (at 118.11 93.98 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "D17" (id 0) (at 118.11 88.4682 0))
+    (property "Reference" "D21" (id 0) (at 118.11 88.4682 0))
     (property "Value" "CMSH3-40MA" (id 1) (at 118.11 90.7796 0))
     (property "Footprint" "Diode_SMD:D_SMA" (id 2) (at 118.11 93.98 0)
@@
   (symbol (lib_id "power:GND") (at 121.92 93.98 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR074" (id 0) (at 121.92 100.33 0)
+    (property "Reference" "#PWR076" (id 0) (at 121.92 100.33 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "22uH" (id 1) (at 133.35 105.41 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "Inductor_SMD:L_Bourns_SRP7028A_7.3x6.6mm" (id 2) (at 132.08 104.14 0)
+    (property "Value" "10uH" (id 1) (at 133.35 105.41 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Inductor_SMD:L_AVX_LMLP07A7" (id 2) (at 132.08 104.14 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:GND") (at 40.64 40.64 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR068" (id 0) (at 40.64 46.99 0)
+    (property "Reference" "#PWR070" (id 0) (at 40.64 46.99 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:GND") (at 48.26 25.4 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR071" (id 0) (at 48.26 31.75 0)
+    (property "Reference" "#PWR073" (id 0) (at 48.26 31.75 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:+3.3VA") (at 40.64 25.4 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR067" (id 0) (at 40.64 29.21 0)
+    (property "Reference" "#PWR069" (id 0) (at 40.64 29.21 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:GND") (at 40.64 67.31 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR070" (id 0) (at 40.64 73.66 0)
+    (property "Reference" "#PWR072" (id 0) (at 40.64 73.66 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:GND") (at 48.26 52.07 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR072" (id 0) (at 48.26 58.42 0)
+    (property "Reference" "#PWR074" (id 0) (at 48.26 58.42 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:+3.3VA") (at 40.64 52.07 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR069" (id 0) (at 40.64 55.88 0)
+    (property "Reference" "#PWR071" (id 0) (at 40.64 55.88 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:+3.3VA") (at 33.02 111.76 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR?" (id 0) (at 33.02 115.57 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Reference" "#PWR068" (id 0) (at 33.02 115.57 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: improve the jank 555 boost circuit
Parts:
- added U57: (no value), symbol Driver_FET:MCP14A0902xMNY
- R48: value 24R -> (none); footprint Resistor_SMD:R_0805_2012Metric -> (none)
Connections:
- net GND: now also U57.4 (GND), U57.5 (GND), U57.9 (GND)
- net at R48.2, U25.3 (Q): now also U57.2 (IN); no longer Q6.4 (G)
- net at C40.1, L4.1, R37.1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: now also U57.1 (VDD), U57.3 (EN), U57.8 (VDD)
- new net: Q6.4 (G), U57.6 (OUT), U57.7 (OUT)
Other:
- note added: "Rated up to 16V input MAX"
- moved on the sheet: C41, C42, D23, L4, Q6

Commit message: correct layout
Parts:
- R48: value (none) -> 24R; footprint (none) -> Resistor_SMD:R_0805_2012Metric
- U57: value (none) -> MCP14A0902-E/SN; footprint (none) -> Package_SO:SO-8_3.9x4.9mm_P1.27mm
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (id 1) (at 148.59 39.37 90))
-    (property "Footprint" "" (id 2) (at 148.59 41.148 90)
+    (property "Value" "24R" (id 1) (at 148.59 39.37 90))
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric" (id 2) (at 148.59 41.148 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (id 1) (at 168.91 53.34 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (id 2) (at 168.91 27.94 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Value" "MCP14A0902-E/SN" (id 1) (at 168.91 53.34 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Package_SO:SO-8_3.9x4.9mm_P1.27mm" (id 2) (at 168.91 27.94 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: minor solar edits
Changed lines of the file:
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@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (polyline (pts (xy 78.74 73.66) (xy 213.36 73.66))
+  (polyline (pts (xy 78.74 73.66) (xy 228.6 73.66))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )

Commit message: selectable voltages on PDMs
Parts:
- U57: footprint Package_SO:SO-8_3.9x4.9mm_P1.27mm -> Package_DFN_QFN:TDFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.4mm
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Package_SO:SO-8_3.9x4.9mm_P1.27mm" (id 2) (at 168.91 27.94 0)
+    (property "Footprint" "Package_DFN_QFN:TDFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.4mm" (id 2) (at 168.91 27.94 0)
       (effects (font (size 1.27 1.27)) hide)
     )
