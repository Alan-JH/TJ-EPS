# Repository Alan-JH/TJ-EPS (continued)

## KiCad design ECAD/TJ-EPS.kicad_pcb (continued)

Schematic: PDM5V.sch, TJ Custom EPS

Parts:
D35: 1N4004; D_SMA
Q61: 2N7002; SOT-23
Q62: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
R270, R276: 100R; R_0805_2012Metric
R271, R272: 10K; R_0805_2012Metric
R273, R274: 100K; R_0805_2012Metric
R275: 10m; R_2010_5025Metric
R277: 2K; R_0805_2012Metric
U71: LT6106; SOT-23-5

Connections:
+5V: Q62.5 (D), Q62.6 (D), Q62.7 (D), Q62.8 (D), R272.1; also elsewhere on the board
GND: D35.2 (A), Q61.2 (S), R271.2, R274.2, R277.2, U71.2 (V-); also elsewhere on the board
unnamed: D35.1 (K), Q62.1 (S), Q62.2 (S), Q62.3 (S), R273.1, R275.2, R276.2, U71.5 (V+)
unnamed: Q61.1 (G), R270.1, R271.1
unnamed: Q61.3 (D), Q62.4 (G), R272.2
unnamed: R276.1, U71.3 (-)
SW5: R275.1, U71.4 (+); also elsewhere on the board
TELEM_ISW5: R277.1, U71.1; also elsewhere on the board
TELEM_VSW5: R273.2, R274.1; also elsewhere on the board

Parts of its further copies:
D32, D33, D34: 1N4004; D_SMA
Q55, Q57, Q59: 2N7002; SOT-23
Q56, Q58, Q60: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
R246, R252, R254, R260, R262, R268: 100R; R_0805_2012Metric
R247, R248, R255, R256, R263, R264: 10K; R_0805_2012Metric
R249, R250, R257, R258, R265, R266: 100K; R_0805_2012Metric
R251, R259, R267: 10m; R_2010_5025Metric
R253, R261, R269: 2K; R_0805_2012Metric
U68, U69, U70: LT6106; SOT-23-5

Connections of its further copies:
+5V: Q56.5 (D), Q56.6 (D), Q56.7 (D), Q56.8 (D), Q58.5 (D), Q58.6 (D), Q58.7 (D), Q58.8 (D), Q60.5 (D), Q60.6 (D), Q60.7 (D), Q60.8 (D), R248.1, R256.1, R264.1; also elsewhere on the board
GND: D32.2 (A), D33.2 (A), D34.2 (A), Q55.2 (S), Q57.2 (S), Q59.2 (S), R247.2, R250.2, R253.2, R255.2, R258.2, R261.2, R263.2, R266.2, R269.2, U68.2 (V-), U69.2 (V-), U70.2 (V-); also elsewhere on the board
unnamed: D32.1 (K), Q56.1 (S), Q56.2 (S), Q56.3 (S), R249.1, R251.2, R252.2, U68.5 (V+)
unnamed: D33.1 (K), Q58.1 (S), Q58.2 (S), Q58.3 (S), R257.1, R259.2, R260.2, U69.5 (V+)
unnamed: D34.1 (K), Q60.1 (S), Q60.2 (S), Q60.3 (S), R265.1, R267.2, R268.2, U70.5 (V+)
unnamed: Q55.1 (G), R246.1, R247.1
unnamed: Q55.3 (D), Q56.4 (G), R248.2
unnamed: Q57.1 (G), R254.1, R255.1
unnamed: Q57.3 (D), Q58.4 (G), R256.2
unnamed: Q59.1 (G), R262.1, R263.1
unnamed: Q59.3 (D), Q60.4 (G), R264.2
unnamed: R252.1, U68.3 (-)
unnamed: R260.1, U69.3 (-)
unnamed: R268.1, U70.3 (-)
SW6: R267.1, U70.4 (+); also elsewhere on the board
SW7: R259.1, U69.4 (+); also elsewhere on the board
SW8: R251.1, U68.4 (+); also elsewhere on the board
TELEM_ISW6: R269.1, U70.1; also elsewhere on the board
TELEM_ISW7: R261.1, U69.1; also elsewhere on the board
TELEM_ISW8: R253.1, U68.1; also elsewhere on the board
TELEM_VSW6: R265.2, R266.1; also elsewhere on the board
TELEM_VSW7: R257.2, R258.1; also elsewhere on the board
TELEM_VSW8: R249.2, R250.1; also elsewhere on the board

Notes on the sheet:
200mV/A

Schematic: PDMBATV.sch, TJ Custom EPS

Parts:
D38: 1N4004; D_SMA
Q67: 2N7002; SOT-23
Q68: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
R294, R300: 100R; R_0805_2012Metric
R295, R296: 10K; R_0805_2012Metric
R297: 200K; R_0805_2012Metric
R298: 100K; R_0805_2012Metric
R299: 10m; R_2010_5025Metric
R301: 2K; R_0805_2012Metric
U74: LT6106; SOT-23-5

Connections:
GND: D38.2 (A), Q67.2 (S), R295.2, R298.2, R301.2, U74.2 (V-); also elsewhere on the board
unnamed: D38.1 (K), Q68.1 (S), Q68.2 (S), Q68.3 (S), R297.1, R299.2, R300.2, U74.5 (V+)
unnamed: Q67.1 (G), R294.1, R295.1
unnamed: Q67.3 (D), Q68.4 (G), R296.2
unnamed: R300.1, U74.3 (-)
SW1: R299.1, U74.4 (+); also elsewhere on the board
TELEM_ISW1: R301.1, U74.1; also elsewhere on the board
TELEM_VSW1: R297.2, R298.1; also elsewhere on the board

Parts of its further copies:
D36, D37, D39: 1N4004; D_SMA
Q63, Q65, Q69: 2N7002; SOT-23
Q64, Q66, Q70: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
R278, R284, R286, R292, R302, R308: 100R; R_0805_2012Metric
R279, R280, R287, R288, R303, R304: 10K; R_0805_2012Metric
R281, R289, R305: 200K; R_0805_2012Metric
R282, R290, R306: 100K; R_0805_2012Metric
R283, R291, R307: 10m; R_2010_5025Metric
R285, R293, R309: 2K; R_0805_2012Metric
U72, U73, U75: LT6106; SOT-23-5

Connections of its further copies:
GND: D36.2 (A), D37.2 (A), D39.2 (A), Q63.2 (S), Q65.2 (S), Q69.2 (S), R279.2, R282.2, R285.2, R287.2, R290.2, R293.2, R303.2, R306.2, R309.2, U72.2 (V-), U73.2 (V-), U75.2 (V-); also elsewhere on the board
unnamed: D36.1 (K), Q64.1 (S), Q64.2 (S), Q64.3 (S), R281.1, R283.2, R284.2, U72.5 (V+)
unnamed: D37.1 (K), Q66.1 (S), Q66.2 (S), Q66.3 (S), R289.1, R291.2, R292.2, U73.5 (V+)
unnamed: D39.1 (K), Q70.1 (S), Q70.2 (S), Q70.3 (S), R305.1, R307.2, R308.2, U75.5 (V+)
unnamed: Q63.1 (G), R278.1, R279.1
unnamed: Q63.3 (D), Q64.4 (G), R280.2
unnamed: Q65.1 (G), R286.1, R287.1
unnamed: Q65.3 (D), Q66.4 (G), R288.2
unnamed: Q69.1 (G), R302.1, R303.1
unnamed: Q69.3 (D), Q70.4 (G), R304.2
unnamed: R284.1, U72.3 (-)
unnamed: R292.1, U73.3 (-)
unnamed: R308.1, U75.3 (-)
SW2: R291.1, U73.4 (+); also elsewhere on the board
SW3: R283.1, U72.4 (+); also elsewhere on the board
SW4: R307.1, U75.4 (+); also elsewhere on the board
TELEM_ISW2: R293.1, U73.1; also elsewhere on the board
TELEM_ISW3: R285.1, U72.1; also elsewhere on the board
TELEM_ISW4: R309.1, U75.1; also elsewhere on the board
TELEM_VSW2: R289.2, R290.1; also elsewhere on the board
TELEM_VSW3: R281.2, R282.1; also elsewhere on the board
TELEM_VSW4: R305.2, R306.1; also elsewhere on the board

Notes on the sheet:
200mV/A

Schematic: Temp+Light.sch, TJ Custom EPS

Parts:
R130: 100K; R_0805_2012Metric
R131: 1K; R_0805_2012Metric
R132: 3K; R_0805_2012Metric
R133: 120K; R_0805_2012Metric
U38: LM358; SO-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: R130.1, U38.8 (V+); also elsewhere on the board
/SolarConditioning/SolarTelem/S1ATelem/PHOTOIN: R132.1, U38.5 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S1ATelem/PHOTOOUT: R132.2, U38.7; also elsewhere on the board
/SolarConditioning/SolarTelem/S1ATelem/TEMPIN: R130.2, U38.3 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S1ATelem/TEMPOUT: R133.2, U38.1; also elsewhere on the board
GND: R131.2, U38.4 (V-), U38.6 (-); also elsewhere on the board
unnamed: R131.1, R133.1, U38.2 (-)

Parts of its further copies:
R134, R138, R142, R146, R150, R154, R158: 100K; R_0805_2012Metric
R135, R139, R143, R147, R151, R155, R159: 1K; R_0805_2012Metric
R136, R140, R144, R148, R152, R156, R160: 3K; R_0805_2012Metric
R137, R141, R145, R149, R153, R157, R161: 120K; R_0805_2012Metric
U39, U40, U41, U42, U43, U44, U45: LM358; SO-8_3.9x4.9mm_P1.27mm

Connections of its further copies:
+3.3VA: R134.1, R138.1, R142.1, R146.1, R150.1, R154.1, R158.1, U39.8 (V+), U40.8 (V+), U41.8 (V+), U42.8 (V+), U43.8 (V+), U44.8 (V+), U45.8 (V+); also elsewhere on the board
/SolarConditioning/SolarTelem/S1BTelem/PHOTOIN: R136.1, U39.5 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S1BTelem/PHOTOOUT: R136.2, U39.7; also elsewhere on the board
/SolarConditioning/SolarTelem/S1BTelem/TEMPIN: R134.2, U39.3 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S1BTelem/TEMPOUT: R137.2, U39.1; also elsewhere on the board
/SolarConditioning/SolarTelem/S2ATelem/PHOTOIN: R140.1, U40.5 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S2ATelem/PHOTOOUT: R140.2, U40.7; also elsewhere on the board
/SolarConditioning/SolarTelem/S2ATelem/TEMPIN: R138.2, U40.3 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S2ATelem/TEMPOUT: R141.2, U40.1; also elsewhere on the board
/SolarConditioning/SolarTelem/S2BTelem/PHOTOIN: R144.1, U41.5 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S2BTelem/PHOTOOUT: R144.2, U41.7; also elsewhere on the board
/SolarConditioning/SolarTelem/S2BTelem/TEMPIN: R142.2, U41.3 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S2BTelem/TEMPOUT: R145.2, U41.1; also elsewhere on the board
/SolarConditioning/SolarTelem/S3ATelem/PHOTOIN: R148.1, U42.5 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S3ATelem/PHOTOOUT: R148.2, U42.7; also elsewhere on the board
/SolarConditioning/SolarTelem/S3ATelem/TEMPIN: R146.2, U42.3 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S3ATelem/TEMPOUT: R149.2, U42.1; also elsewhere on the board
/SolarConditioning/SolarTelem/S3BTelem/PHOTOIN: R152.1, U43.5 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S3BTelem/PHOTOOUT: R152.2, U43.7; also elsewhere on the board
/SolarConditioning/SolarTelem/S3BTelem/TEMPIN: R150.2, U43.3 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S3BTelem/TEMPOUT: R153.2, U43.1; also elsewhere on the board
/SolarConditioning/SolarTelem/S4ATelem/PHOTOIN: R156.1, U44.5 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S4ATelem/PHOTOOUT: R156.2, U44.7; also elsewhere on the board
/SolarConditioning/SolarTelem/S4ATelem/TEMPIN: R154.2, U44.3 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S4ATelem/TEMPOUT: R157.2, U44.1; also elsewhere on the board
/SolarConditioning/SolarTelem/S4BTelem/PHOTOIN: R160.1, U45.5 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S4BTelem/PHOTOOUT: R160.2, U45.7; also elsewhere on the board
/SolarConditioning/SolarTelem/S4BTelem/TEMPIN: R158.2, U45.3 (+); also elsewhere on the board
/SolarConditioning/SolarTelem/S4BTelem/TEMPOUT: R161.2, U45.1; also elsewhere on the board
GND: R135.2, R139.2, R143.2, R147.2, R151.2, R155.2, R159.2, U39.4 (V-), U39.6 (-), U40.4 (V-), U40.6 (-), U41.4 (V-), U41.6 (-), U42.4 (V-), U42.6 (-), U43.4 (V-), U43.6 (-), U44.4 (V-), U44.6 (-), U45.4 (V-), U45.6 (-); also elsewhere on the board
unnamed: R135.1, R137.1, U39.2 (-)
unnamed: R139.1, R141.1, U40.2 (-)
unnamed: R143.1, R145.1, U41.2 (-)
unnamed: R147.1, R149.1, U42.2 (-)
unnamed: R151.1, R153.1, U43.2 (-)
unnamed: R155.1, R157.1, U44.2 (-)
unnamed: R159.1, R161.1, U45.2 (-)

Notes on the sheet:
Transimpedance amp using Photodiode Cathode
Vout = Idiode*R
PTC Resistor Connected to GND, resistance 500R

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
Board: 2 copper layers, 654 parts (0 on the bottom side), 421 nets, no tracks yet.

## KiCad design ECAD/Cell/Cell.kicad_pcb

Board: 2 copper layers, 9 parts (6 on the bottom side), 8 nets.

Parts:
BT1: 18650; BatteryHolder_Keystone_1042_1x18650
C29: 0.1uF; C_0805_2012Metric
H5, H6: Contact; MountingHole_3.2mm_M3_DIN965_Pad
Q13, Q14: DMN2028USS; SOIC-8_3.9x4.9mm_P1.27mm
R38: 330R; R_0805_2012Metric
R39: 2.2K; R_0805_2012Metric
U11: BQ29707; WSON-6_1.5x1.5mm_P0.5mm

Connections:
/+: BT1.1, H5.1, R38.1
/-: H6.1, Q14.1, Q14.2, Q14.3, R39.2
unnamed: BT1.2, C29.2, Q13.1, Q13.2, Q13.3, U11.4
unnamed: C29.1, R38.2, U11.5
unnamed: Q13.4, U11.3
unnamed: Q13.5, Q13.6, Q13.7, Q13.8, Q14.5, Q14.6, Q14.7, Q14.8
unnamed: Q14.4, U11.2
unnamed: R39.1, U11.6

## Commit log

2021-12-19 add mppt
2021-12-20 First version MPPT
2021-12-20 Always forget to add the gitignore
2021-12-20 Cell level and pack level protections, and charge balancing
2021-12-20 add vbat and ibat telemetry read
2021-12-21 add battery temperature telemetry and heaters
2021-12-22 revamp solar conditioning, use lt3652 instead of homebrew buck converter
2021-12-22 Spec out switching controllers for PCMs
2021-12-23 Finish components for buck converters, add UVLO feature, correct all mosfet orientations
2021-12-23 Finish speccing out components for 12V boost
2021-12-24 Remove zeners, add PDMs, correct MPPT setpoint controller
2021-12-24 Cleanup, add yellow fill to symbols, add MAX4373
2021-12-24 astable 555 boost concept
2021-12-24 rearrange the stack headers to make some damn sense *looks at clydespace*
2021-12-25 spec out new cell protection IC and mosfets, figured out current limit calculation
2021-12-26 Add OCP, resize some sheets
2021-12-29 fix the bidirectional ocp to actually be bidirectional
2021-12-30 start placing battery telemetry node
2021-12-31 bidirectional inhibits, remove unrealistic zener, replace all irf7425 with irf7458
2021-12-31 add programming to micro
2021-12-31 Boot jumper
2022-01-01 Fourth BCR, with boost stage
2022-01-02 Connect PDMs, add stm32 on eps board, add bcrout current telemetry, improve spacing
2022-01-02 add i2c
2022-01-02 mounting holes
2022-01-02 remove unused schematics
2022-01-02 add comments and titles
2022-01-02 Add USB charge to BCR3B
2022-01-02 Make sub-sheets prettier
2022-01-02 Add watchdog timers
2022-01-02 connect handshake pin
2022-01-02 ceramics
2022-01-03 555 retry timer?
2022-01-04 implement a retry timer
2022-01-04 fix a minor wire mixup
2022-01-04 connect retry timers, organize sheet
2022-01-04 Correct watchdog implementation
    in case of a latchup event, reset pin wouldn't work. need to cycle power to chip
2022-01-04 Add cell separation
2022-01-04 update values
2022-01-05 Implement pulse resets
2022-01-05 Replace tantalums with MLCCs
2022-01-05 get rid of series capacitors
2022-01-05 add solar telemetry sheet
2022-01-06 Implement solar telemetry, add a sheet layout
2022-01-07 add amux
2022-01-07 connect amux
2022-01-08 Add PDM control using shift registers
2022-01-08 Annotate and begin adding footprints
2022-01-09 add some more footprints
2022-01-10 Add all IC footprints
2022-01-11 add cell protection concept, make the protection board integrated into main board
    consider removing cell level protection and relying on integrated cell protection
2022-01-12 add a bunch of cap and shunt resistor footprints
2022-01-12 Remove cell level protections, rely on 18650 internal protections
2022-01-13 Major descope, remove 12V boost and all related circuitry
2022-01-13 Update stack header pinouts and re-annotate
2022-01-13 Get rid of unused sch files
2022-01-13 Condense muxes and add srrst
2022-01-13 cleanup
2022-01-14 Despec inductor for buck converters, finish adding footprints, general schematic cleanup
2022-01-14 Schematic Cleanup
2022-01-14 last footprint
2022-01-14 meme layout
2022-01-14 Fix two different +BATT labels causing batbus to be connected to raw battv
2022-01-14 very minor formatting
2022-01-14 remove residual label
2022-01-14 add track widths
2022-01-14 move bat board stuff aside
2022-01-14 Split up into 3 projects for separate boards
2022-01-14 Add standard dimensions to batt
    TODO: replace footprint of 18650
2022-01-18 254 footprint
2022-01-19 18500 footprint
2022-01-20 Further descope: remove SA4
2022-01-20 welded 18650
2022-01-21 wip: refine shunt resistor selection, add inhibits
2022-01-21 inhibit resistor values, among other things
2022-01-21 handle inhibit power draw
2022-01-22 Finish revamp of protection layout
2022-01-22 footprint and layout update
2022-01-24 Restandardize stack headers a bit
2022-01-24 moving some connectors
2022-01-25 downspec heater mosfets
2022-01-26 Continue to route
2022-01-26 more routing
2022-01-27 route route route some more
2022-01-27 just a bit more
    I should sleep
2022-01-27 Finish routing vbat power path
2022-01-27 replace stack header footprint
2022-01-28 swd with debug, and replace boot jumper with solder jumper
2022-01-28 place heater and thermistor stuff
2022-01-29 Finish laying out battery pcb v1, now time for revisions
2022-01-29 branding and silk updates
2022-01-29 partial via stitch and gerber export
2022-01-29 back to 2 layer
2022-01-29 gerb export
2022-01-29 Round off some corners and set up eps board for routing
2022-01-31 work
2022-02-01 Replace EVERY LT6106 with INA180A3
    Friendship ended with LT6106
    now ina180 is my best friend
2022-02-01 change some power flags for latchup prevention
2022-02-01 4 layer + fix pdm gate SRs
2022-02-02 route some stuff, realize 0603 is probably necessary
2022-02-02 dunno what happened here but I'll go with it
2022-02-02 0603 and route
2022-02-05 route pdms some more
2022-02-06 move silkscreens around
2022-02-08 route
2022-02-14 correct setpoint circuitry
2022-03-19 Push KiCAD v6
2022-03-20 respec and consolidate
2022-03-20 improve the jank 555 boost circuit
2022-03-21 correct layout
2022-03-21 push kicad v6 gitignore
2022-03-22 remove separate spi interface
2022-03-24 minor solar edits
2022-03-24 who needs ovp anyways
2022-03-24 move inhibits to battery, resize sheet
2022-03-24 move heater circuitry
2022-03-25 set lower latching ocp
2022-03-26 minor fixes
2022-03-26 selectable voltages on PDMs
2022-03-26 descope to 10 pdms, replace mcp3208 with mcp3008 bc of stock
2022-03-26 move UVP to battery
2022-03-26 note about input
2022-03-26 enlarge comment
2022-03-28 remove flex pcb, move to battery board
2022-03-28 push rev 2 (no more silly numbering conventions)
2022-03-28 comment update
2022-03-28 regulator
2022-03-29 Respect mosfets for heaters, organize, inductor footprint
2022-03-29 layout and footprints
2022-03-29 routing and stuff
2022-03-30 route inhibits
2022-03-31 ocp route
2022-04-01 This is more crowded than it needs to be
2022-04-01 Save Fit
    fitted parts onto board, just want to save it somewhere.
2022-04-01 move solar to daughterboard... again. Also replace all 0603 resistor with 0805
2022-04-03 Micro + PCM blocks
    Micro + PCM blocks
2022-04-04 Revert "Micro + PCM blocks"
    This reverts commit bd53ca95fb26b4e6798500a23db46c8297649bcb.
2022-04-04 Revert to Old
    Revert
2022-04-04 Microcontroller new
    Microcontroller new
2022-04-05 Poosh
    Pushed push push pushed?
2022-04-05 cleanup copper pours
2022-04-05 simplify reset and retry
2022-04-05 reannotate and cleanup some more
2022-04-06 remove jank heater trace
2022-04-07 10Switches
    Routed the 10 switches
2022-04-07 Placement of switches and stuff
    Placement
2022-04-08 proposed switch layout
2022-04-09 Route stack header past switches
    Route stack header past switches
2022-04-10 3V3 battery heaters
2022-04-10 flip PDM current monitors
2022-04-10 small edits
2022-04-13 Switch telem and switching
    Switch telem and switching
2022-04-13 Bad 5v
    bad 5v trace
2022-04-13 battery work + switch to two layer
2022-04-13 Route pwr
    Roots
2022-04-14 hands
    ...
    Finished :)
2022-04-14 Thick PCM->BCR
    Thick PCM->BCR
2022-04-14 Holes
    Holesssss
2022-04-16 cleanup eps
2022-04-17 New holes
    Holez
2022-04-19 battery edits
2022-04-20 add parts and work on battery
2022-04-20 battery work
2022-04-20 Com
    ComComCOmHealthComommmmMomomOMOmOm
2022-04-20 revert kiran's mistake
2022-04-20 finish battery
2022-04-21 eps cleanup
2022-04-21 track cleanup
2022-04-21 Finishing touches and DRC cleanup
2022-04-22 Move silkscreen off of vias and MILESTONE V1 COMPLETE
2022-04-22 solar edits
2022-04-23 some solar work
2022-04-25 solar route
2022-04-26 solar footprint work
2022-04-27 solar work
2022-04-28 descope solar LV input
2022-05-01 value editing
2022-05-01 Finish updating readme
2022-05-02 solar progress
2022-05-02 finish placing solar components
2022-05-02 current monitor
2022-05-02 finish solar routing except telem
2022-05-04 finish solar
2022-05-05 boost
2022-05-06 add 5v charge back in
2022-05-06 route usb charge and add inductor keepouts
2022-05-06 minor trace edits
2022-05-16 minor routing change
2022-05-16 remove 2 pdms
2022-06-02 gitignore output file
2022-06-02 gitignore
2022-06-02 gitinore
2022-06-02 ignore
