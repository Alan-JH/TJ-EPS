# Repository Alan-JH/TJ-EPS (continued)

## KiCad design ECAD/SolarTelem/SolarTelem.kicad_pcb

Board: 2 copper layers, 45 parts (0 on the bottom side), 43 nets, no tracks yet.

Parts:
C1, C2: 0.1uF; C_0805_2012Metric
H1, H2, H3, H4: M2.5; MountingHole_2.7mm_M2.5_DIN965_Pad
J1: S1A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J2: S1B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J3: S2A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J4: S2B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J5: S3A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J6: S3B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J9: OUT; PinSocket_1x07_P1.27mm_Vertical
R1, R5, R9, R13, R17, R21: 100K; R_0805_2012Metric
R2, R6, R10, R14, R18, R22: 1K; R_0805_2012Metric
R3, R7, R11, R15, R19, R23: 3K; R_0805_2012Metric
R4, R8, R12, R16, R20, R24: 120K; R_0805_2012Metric
U1, U2: MCP3208; SO-16_3.9x9.9mm_P1.27mm
U3, U4, U5, U6, U7, U8: LM358; SO-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: C1.1, C2.1, J9.1, R1.1, R5.1, R9.1, R13.1, R17.1, R21.1, U1.15, U1.16, U2.15, U2.16, U3.8, U4.8, U5.8, U6.8, U7.8, U8.8
/CS0: J9.5, U1.10
/CS1: J9.6, U2.10
/MISO: J9.3, U1.12, U2.12
/MOSI: J9.4, U1.11, U2.11
/S1ATelem/PHOTOIN: J1.3, R3.1, U3.5
/S1ATelem/PHOTOOUT: R3.2, U1.2, U3.7
/S1ATelem/TEMPIN: J1.2, R1.2, U3.3
/S1ATelem/TEMPOUT: R4.2, U1.1, U3.1
/S1BTelem/PHOTOIN: J2.3, R7.1, U4.5
/S1BTelem/PHOTOOUT: R7.2, U1.4, U4.7
/S1BTelem/TEMPIN: J2.2, R5.2, U4.3
/S1BTelem/TEMPOUT: R8.2, U1.3, U4.1
/S2ATelem/PHOTOIN: J3.3, R11.1, U5.5
/S2ATelem/PHOTOOUT: R11.2, U1.6, U5.7
/S2ATelem/TEMPIN: J3.2, R9.2, U5.3
/S2ATelem/TEMPOUT: R12.2, U1.5, U5.1
/S2BTelem/PHOTOIN: J4.3, R15.1, U6.5
/S2BTelem/PHOTOOUT: R15.2, U1.8, U6.7
/S2BTelem/TEMPIN: J4.2, R13.2, U6.3
/S2BTelem/TEMPOUT: R16.2, U1.7, U6.1
/S3ATelem/PHOTOIN: J5.3, R19.1, U7.5
/S3ATelem/PHOTOOUT: R19.2, U2.2, U7.7
/S3ATelem/TEMPIN: J5.2, R17.2, U7.3
/S3ATelem/TEMPOUT: R20.2, U2.1, U7.1
/S3BTelem/PHOTOIN: J6.3, R23.1, U8.5
/S3BTelem/PHOTOOUT: R23.2, U2.4, U8.7
/S3BTelem/TEMPIN: J6.2, R21.2, U8.3
/S3BTelem/TEMPOUT: R24.2, U2.3, U8.1
/SCK: J9.2, U1.13, U2.13
GND: C1.2, C2.2, H1.1, H2.1, H3.1, H4.1, J9.7, R2.2, R6.2, R10.2, R14.2, R18.2, R22.2, U1.9, U1.14, U2.9, U2.14, U3.4, U3.6, U4.4, U4.6, U5.4, U5.6, U6.4, U6.6, U7.4, U7.6, U8.4, U8.6
unnamed: J1.1, J1.4
unnamed: J2.1, J2.4
unnamed: J3.1, J3.4
unnamed: J4.1, J4.4
unnamed: J5.1, J5.4
unnamed: J6.1, J6.4
unnamed: R2.1, R4.1, U3.2
unnamed: R6.1, R8.1, U4.2
unnamed: R10.1, R12.1, U5.2
unnamed: R14.1, R16.1, U6.2
unnamed: R18.1, R20.1, U7.2
unnamed: R22.1, R24.1, U8.2

## KiCad design ECAD/TJ-EPS.kicad_pcb

Parts:
C1, C2, C4, C5, C9, C10, C11, C12, C93: 0.1uF; C_0805_2012Metric
C3, C6, C94: 0.01uF; C_0805_2012Metric
C7, C8: 20pF; C_0805_2012Metric
C13: 10uF; C_0805_2012Metric
H1: Stack Header 2; PinSocket_2x26_P2.54mm_Vertical
H2: Stack Header 1; PinSocket_2x26_P2.54mm_Vertical
J1: SWD; PinHeader_1x04_P2.54mm_Horizontal
J2: BOOT; PinHeader_1x03_P2.54mm_Vertical
MH1, MH2, MH3, MH4: M3; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
Q1: 2N7002; SOT-23
Q2: IRF7425; SOIC-8_3.9x4.9mm_P1.27mm
R1: 50K; R_0805_2012Metric
R2: 270K; R_0805_2012Metric
R3, R4, R9: 10K; R_0805_2012Metric
R5, R6: 100K; R_0805_2012Metric
R7, R8: 2.2K; R_0805_2012Metric
TH1: 100K NTC; R_1206_3216Metric
U1, U3, U60: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm
U2: MAX6369; SOT-23-8
U4: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y1: 8MHz; Crystal_HC49-4H_Vertical

Connections:
+3V3: C1.1, C2.1, C5.1, C93.1, H2.29, H2.30, Q2.1 (S), Q2.2 (S), Q2.3 (S), R2.1, R3.1, R4.1, R7.1, R8.1, U1.24 (VCC), U2.4 (SET0), U2.5 (SET1), U2.6 (SET2), U2.8 (VCC), U3.24 (VCC), U60.24 (VCC); also elsewhere on the board
+5V: H2.27, H2.28; also elsewhere on the board
/BOOT0: R6.1, U4.44 (BOOT0)
/BOOT1: R5.1, U4.20 (PB2)
/HANDSHAKE: R1.1, U2.1 (WDI), U4.25 (PB12)
/MISO: H1.31, U4.40 (PB4)
/MOSI: H1.33, U4.41 (PB5)
/RESET: R9.2, U4.7 (NRST)
/SCK: H1.29, U4.39 (PB3)
/SCL: H1.43, R8.2, U4.42 (PB6)
/SDA: H1.41, R7.2, U4.43 (PB7)
/SS: H1.35, U4.38 (PA15)
/SWDCLK: J1.3, U4.37 (PA14)
/SWDIO: J1.2, U4.34 (PA13)
BCR_OUT: H2.39, H2.40, H2.41, H2.42; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C93.2, C94.2, H2.9, H2.10, H2.23, H2.24, H2.31, H2.32, H2.43, H2.44, J1.4, J2.3, MH1.1, MH2.1, MH3.1, MH4.1, Q1.2 (S), R1.2, R5.2, TH1.2, U1.12 (GND), U1.15 (~E), U2.2 (GND), U3.12 (GND), U3.15 (~E), U4.8 (VSSA), U4.23 (VSS), U4.35 (VSS), U4.47 (VSS), U60.12 (GND), U60.15 (~E); also elsewhere on the board
I_SA1A: U1.8 (I1); also elsewhere on the board
I_SA1B: U1.7 (I2); also elsewhere on the board
I_SA2A: U1.5 (I4); also elsewhere on the board
I_SA2B: U1.4 (I5); also elsewhere on the board
I_SA3A: U1.2 (I7); also elsewhere on the board
I_SA3B: U1.23 (I8); also elsewhere on the board
I_SA4A: U1.21 (I10); also elsewhere on the board
I_SA4B: U1.20 (I11); also elsewhere on the board
MUX0OUT: C3.1, U1.1 (COM), U4.10 (PA0)
MUX1OUT: C6.1, U3.1 (COM), U4.11 (PA1)
MUX2OUT: C94.1, U4.12 (PA2), U60.1 (COM)
unnamed: C7.1, U4.5 (PD0), Y1.1
unnamed: C8.1, U4.6 (PD1), Y1.2
unnamed: J2.2, R6.2
unnamed: Q1.1 (G), R3.2, U2.7 (~WDO)
unnamed: Q1.3 (D), Q2.4 (G), R4.2
PCM_IN: H2.35, H2.36; also elsewhere on the board
PDMRST: U4.17 (PA7); also elsewhere on the board
RST3V3: U4.29 (PA8); also elsewhere on the board
RST5V: U4.30 (PA9); also elsewhere on the board
RSTBATV: U4.31 (PA10); also elsewhere on the board
S0: U1.10 (S0), U3.10 (S0), U4.45 (PB8), U60.10 (S0)
S1: U1.11 (S1), U3.11 (S1), U4.46 (PB9), U60.11 (S1)
S2: U1.14 (S2), U3.14 (S2), U4.21 (PB10), U60.14 (S2)
S3: U1.13 (S3), U3.13 (S3), U4.22 (PB11), U60.13 (S3)
SOLAR_CS0: U4.18 (PB0); also elsewhere on the board
SOLAR_CS1: U4.19 (PB1); also elsewhere on the board
SOLAR_MISO: U4.27 (PB14); also elsewhere on the board
SOLAR_MOSI: U4.28 (PB15); also elsewhere on the board
SOLAR_SCK: U4.26 (PB13); also elsewhere on the board
SRCLK: U4.14 (PA4); also elsewhere on the board
SRLCH: U4.15 (PA5); also elsewhere on the board
SRSERIN: U4.16 (PA6); also elsewhere on the board
SW1: H2.11; also elsewhere on the board
SW2: H2.12; also elsewhere on the board
SW3: H2.13; also elsewhere on the board
SW4: H2.14; also elsewhere on the board
SW5: H2.16; also elsewhere on the board
SW6: H2.15; also elsewhere on the board
SW7: H2.18; also elsewhere on the board
SW8: H2.17; also elsewhere on the board
SW9: H2.20; also elsewhere on the board
SW10: H2.19; also elsewhere on the board
SW11: H2.22; also elsewhere on the board
SW12: H2.21; also elsewhere on the board
TELEM_I3V3: U60.17 (I14); also elsewhere on the board
TELEM_I5V: U60.18 (I13); also elsewhere on the board
TELEM_IBATV: U60.19 (I12); also elsewhere on the board
TELEM_IBCROUT: U1.18 (I13); also elsewhere on the board
TELEM_ISW1: U60.9 (I0); also elsewhere on the board
TELEM_ISW2: U60.8 (I1); also elsewhere on the board
TELEM_ISW3: U60.7 (I2); also elsewhere on the board
TELEM_ISW4: U60.6 (I3); also elsewhere on the board
TELEM_ISW5: U60.5 (I4); also elsewhere on the board
TELEM_ISW6: U60.4 (I5); also elsewhere on the board
TELEM_ISW7: U60.3 (I6); also elsewhere on the board
TELEM_ISW8: U60.2 (I7); also elsewhere on the board
TELEM_ISW9: U60.23 (I8); also elsewhere on the board
TELEM_ISW10: U60.22 (I9); also elsewhere on the board
TELEM_ISW11: U60.21 (I10); also elsewhere on the board
TELEM_ISW12: U60.20 (I11); also elsewhere on the board
TELEM_TBRD: C4.1, R2.2, TH1.1, U1.16 (I15)
TELEM_V3V3: U3.17 (I14); also elsewhere on the board
TELEM_V5V: U3.18 (I13); also elsewhere on the board
TELEM_VBATV: U3.19 (I12); also elsewhere on the board
TELEM_VBCROUT: U1.19 (I12); also elsewhere on the board
TELEM_VSW1: U3.9 (I0); also elsewhere on the board
TELEM_VSW2: U3.8 (I1); also elsewhere on the board
TELEM_VSW3: U3.7 (I2); also elsewhere on the board
TELEM_VSW4: U3.6 (I3); also elsewhere on the board
TELEM_VSW5: U3.5 (I4); also elsewhere on the board
TELEM_VSW6: U3.4 (I5); also elsewhere on the board
TELEM_VSW7: U3.3 (I6); also elsewhere on the board
TELEM_VSW8: U3.2 (I7); also elsewhere on the board
TELEM_VSW9: U3.23 (I8); also elsewhere on the board
TELEM_VSW10: U3.22 (I9); also elsewhere on the board
TELEM_VSW11: U3.21 (I10); also elsewhere on the board
TELEM_VSW12: U3.20 (I11); also elsewhere on the board
VDD: C9.1, C10.1, C11.1, C12.1, C13.1, J1.1, J2.1, Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), R9.1, U4.1 (VBAT), U4.9 (VDDA), U4.24 (VDD), U4.36 (VDD), U4.48 (VDD); also elsewhere on the board
VUSB: H2.45, H2.46; also elsewhere on the board
V_SA1: U1.9 (I0); also elsewhere on the board
V_SA2: U1.6 (I3); also elsewhere on the board
V_SA3: U1.3 (I6); also elsewhere on the board
V_SA4: U1.22 (I9); also elsewhere on the board

Notes on the sheet:
Top resistor selected for 5C center operating temperature
AMUX
Thermistor
Stack Headers
Programming Headers & the like
Latchup WDT

Parts:
BT1, BT2, BT3, BT4: 18650; BatteryHolder_Keystone_1042_1x18650
C14, C15, C16, C18, C19, C22, C23, C24, C26, C27, C28, C29: 0.1uF; C_0805_2012Metric
C17, C30: 10uF; C_0805_2012Metric
C20, C21: 20pF; C_0805_2012Metric
C25: 0.33uF; C_0805_2012Metric
F1, F2: 7A; R_1206_3216Metric
H3: Stack Header 2; PinSocket_2x26_P2.54mm_Vertical
H4: Stack Header 1; PinSocket_2x26_P2.54mm_Vertical
J3: SWD; PinHeader_1x04_P2.54mm_Horizontal
J4: BOOT; PinHeader_1x03_P2.54mm_Vertical
MH5, MH6, MH7, MH8: M3; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
Q3, Q5, Q7, Q8: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
Q4, Q6, Q10, Q12: Si4186DY; SOIC-8_3.9x4.9mm_P1.27mm
Q9: 2N7002; SOT-23
Q11: IRF7425; SOIC-8_3.9x4.9mm_P1.27mm
R10, R36: 22K; R_0805_2012Metric
R11, R24, R26, R30, R35: 10K; R_0805_2012Metric
R12: 10m; R_2010_5025Metric
R13, R16, R17, R29, R34: 100R; R_0805_2012Metric
R14: 2K; R_0805_2012Metric
R15, R18, R25, R27, R28: 100K; R_0805_2012Metric
R19: 24K; R_0805_2012Metric
R20: 16K; R_0805_2012Metric
R21, R23: 50K; R_0805_2012Metric
R22: 790K; R_0805_2012Metric
R31: 1K; R_0805_2012Metric
R32: 160R; R_0805_2012Metric
R33: 260R; R_0805_2012Metric
SW1: INHIBIT3; Hirose_DF13-02P-1.25DSA_1x02_P1.25mm_Vertical
SW2: INHIBIT4; Hirose_DF13-02P-1.25DSA_1x02_P1.25mm_Vertical
U5: LM358; SO-8_3.9x4.9mm_P1.27mm
U6: LT6106; SOT-23-5
U7: ADR4530; SOIC-8_3.9x4.9mm_P1.27mm
U8: MAX6369; SOT-23-8
U9: LTC4365TS8-1; TSOT-23-8
U10: BQ29209; Texas_S-PVSON-N8_ThermalVias
U11: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y2: 8MHz; Crystal_HC49-4H_Vertical

Connections:
+3V3: C19.1, H4.29, H4.30, Q11.1 (S), Q11.2 (S), Q11.3 (S), R24.1, R26.1, U8.4 (SET0), U8.5 (SET1), U8.6 (SET2), U8.8 (VCC); also elsewhere on the board
+5V: H4.27, H4.28; also elsewhere on the board
/Battery/BOOT0: R28.1, U11.44 (BOOT0)
/Battery/BOOT1: R27.1, U11.20 (PB2)
/Battery/H1BOT: U11.46 (PB9); also elsewhere on the board
/Battery/H1TOP: U11.45 (PB8); also elsewhere on the board
/Battery/H2BOT: U11.22 (PB11); also elsewhere on the board
/Battery/H2TOP: U11.21 (PB10); also elsewhere on the board
/Battery/H3BOT: U11.26 (PB13); also elsewhere on the board
/Battery/H3TOP: U11.25 (PB12); also elsewhere on the board
/Battery/H4BOT: U11.28 (PB15); also elsewhere on the board
/Battery/H4TOP: U11.27 (PB14); also elsewhere on the board
/Battery/HANDSHAKE: R21.1, U8.1 (WDI), U11.18 (PB0)
/Battery/MISO: H3.31, U11.40 (PB4)
/Battery/MOSI: H3.33, U11.41 (PB5)
/Battery/RESET: R30.2, U11.7 (NRST)
/Battery/SCK: H3.29, U11.39 (PB3)
/Battery/SS: H3.35, U11.38 (PA15)
/Battery/SWDCLK: J3.3, U11.37 (PA14)
/Battery/SWDIO: J3.2, U11.34 (PA13)
/Battery/TBAT1: U11.10 (PA0); also elsewhere on the board
/Battery/TBAT2: U11.11 (PA1); also elsewhere on the board
/Battery/TBAT3: U11.12 (PA2); also elsewhere on the board
/Battery/TBAT4: U11.13 (PA3); also elsewhere on the board
/Battery/TELEM_IBAT: R14.1, U5.5 (+), U6.1, U11.15 (PA5)
/Battery/TELEM_IBATDIR: R36.1, U5.1
/Battery/TELEM_VBAT: C14.1, R10.2, R11.1, U11.14 (PA4)
BCR_OUT: H4.39, H4.40, H4.41, H4.42, R12.2, R13.2, U5.3 (+), U5.8 (V+), U6.5 (V+); also elsewhere on the board
GND: C14.2, C19.2, C20.2, C21.2, C26.2, C27.2, C28.2, C29.2, C30.2, H4.9, H4.10, H4.23, H4.24, H4.31, H4.32, H4.43, H4.44, J3.4, J4.3, MH5.1, MH6.1, MH7.1, MH8.1, Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q9.2 (S), R11.2, R14.2, R21.2, R27.2, R35.2, U5.4 (V-), U6.2 (V-), U8.2 (GND), U11.8 (VSSA), U11.23 (VSS), U11.35 (VSS), U11.47 (VSS); also elsewhere on the board
unnamed: BT1.2 (-), BT2.1 (+), BT3.2 (-), BT4.1 (+), R33.1, R34.1
unnamed: BT2.2 (-), BT4.2 (-), C17.2, C18.2, C22.2, C25.2, Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q12.1 (S), Q12.2 (S), Q12.3 (S), R20.2, R23.2, U7.4 (GND), U9.4 (GND), U10.5 (GND), U10.6 (~CB_EN), U10.9 (PGND)
unnamed: C15.1, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q5.1 (S), Q5.2 (S), Q5.3 (S), R17.1, R18.1
unnamed: C15.2, Q3.4 (G), Q5.4 (G), R15.1, SW1.2 (B)
unnamed: C16.1, Q4.4 (G), Q6.4 (G), R18.2, SW2.1 (A)
unnamed: C16.2, Q4.1 (S), Q4.2 (S), Q4.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), R15.2, R16.2
unnamed: C17.1, C18.1, Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), U7.2 (IN)
unnamed: C20.1, U11.5 (PD0), Y2.1
unnamed: C21.1, U11.6 (PD1), Y2.2
unnamed: C22.1, R29.2, U10.7 (VDD)
unnamed: C23.1, R32.2, U10.1 (VC2)
unnamed: C23.2, C24.1, R33.2, U10.2 (VC1)
unnamed: C24.2, R34.2, U10.3 (VC1_CB)
unnamed: C25.1, U10.4 (CD)
unnamed: F1.1, F2.2, Q12.5 (D), Q12.6 (D), Q12.7 (D), Q12.8 (D)
unnamed: F1.2, Q10.1 (S), Q10.2 (S), Q10.3 (S), U9.7 (Vout)
unnamed: J4.2, R28.2
unnamed: Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), R12.1, U5.2 (-), U6.4 (+)
unnamed: Q7.1 (S), Q7.2 (S), Q7.3 (S), Q8.1 (S), Q8.2 (S), Q8.3 (S)
unnamed: Q7.4 (G), Q8.4 (G), U5.7
unnamed: Q9.1 (G), R24.2, U8.7 (~WDO)
unnamed: Q10.4 (G), U9.8 (GATE)
unnamed: Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), R22.1, R25.1, U9.1 (Vin)
unnamed: Q9.3 (D), Q11.4 (G), R26.2
unnamed: Q12.4 (G), R31.1
unnamed: R13.1, U6.3 (-)
unnamed: R16.1, SW2.2 (B)
unnamed: R17.2, SW1.1 (A)
unnamed: R19.1, U7.6 (OUT)
unnamed: R19.2, R20.1, U5.6 (-)
unnamed: R22.2, R23.1, U9.3 (OV)
unnamed: R25.2, U9.2 (UV), U9.5 (~SHDN)
unnamed: R31.2, U10.8 (OUT)
unnamed: R35.1, R36.2, U11.16 (PA6)
PCM_IN: H4.35, H4.36; also elsewhere on the board
SW1: H4.11; also elsewhere on the board
SW2: H4.12; also elsewhere on the board
SW3: H4.13; also elsewhere on the board
SW4: H4.14; also elsewhere on the board
SW5: H4.16; also elsewhere on the board
SW6: H4.15; also elsewhere on the board
SW7: H4.18; also elsewhere on the board
SW8: H4.17; also elsewhere on the board
SW9: H4.20; also elsewhere on the board
SW10: H4.19; also elsewhere on the board
SW11: H4.22; also elsewhere on the board
SW12: H4.21; also elsewhere on the board
VDD: C26.1, C27.1, C28.1, C29.1, C30.1, J3.1, J4.1, Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), R30.1, U11.1 (VBAT), U11.9 (VDDA), U11.24 (VDD), U11.36 (VDD), U11.48 (VDD); also elsewhere on the board
VUSB: H4.45, H4.46; also elsewhere on the board

Notes on the sheet:
Balancing and Protections
OUT is pulled high in OV condition, after 3 second delay OV is fixed at 4.3V per cell
Inhibits
V and I Telemetry
Semidestructive protection in case OVP exists for more than 3 seconds
200mV/A
ROUTE CAREFULLY! 0.15mV error is enough to be problematic
If high, charging, else discharging
~~6A Bidirectional OCP
8.4V rising/7.98V falling OVP (0.5V OV rising threshold, 0.475V OV falling threshold)

Parts:
C35, C36, C38, C39, C40: 0.1uF; C_0805_2012Metric
C37: 0.47uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8: CMSH3-40MA; D_SMA
D9, D10, D11, D12, D13, D14, D15, D16: 1N4004; D_SMA
H5, H6, H7, H8: M2.5; MountingHole_2.7mm_M2.5_DIN965_Pad
J5: S1A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J6: S1B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J7: S2A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J8: S2B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J9: S3A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J10: S3B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J11: S4A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J12: S4B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J13: TELEM_IN; PinHeader_1x07_P1.27mm_Vertical
Q25: IRF7425; SOIC-8_3.9x4.9mm_P1.27mm
Q26: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
R65: 10K; R_0805_2012Metric
R66, R70: 100R; R_0805_2012Metric
R67: 220K; R_0805_2012Metric
R68: 100K; R_0805_2012Metric
R69: 10m; R_2010_5025Metric
R71: 2K; R_0805_2012Metric
SW3: INHIBIT 1; Hirose_DF13-02P-1.25DSA_1x02_P1.25mm_Vertical
U12: LTC4412xS6; TSOT-23-6
U13: MCP3208; SO-16_3.9x9.9mm_P1.27mm
U14: LT6106; SOT-23-5
U15: ATtiny84A-SSU; SOIC-14_3.9x8.7mm_P1.27mm
U16: L78L33_SO8; SOIC-8_3.9x4.9mm_P1.27mm
U17, U18: MCP4812; MSOP-8_3x3mm_P0.65mm

Connections:
+3.3VA: C35.1, C36.1, C38.1, C39.1, C40.1, J13.1, U13.15 (Vref), U13.16 (Vdd), U15.1 (VCC), U16.1 (OUT), U17.1 (Vdd), U18.1 (Vdd); also elsewhere on the board
/SolarConditioning/ADCCS: U13.10 (~CS~/SHDN), U15.2 (XTAL1/PB0)
/SolarConditioning/DAC1CS: U15.3 (XTAL2/PB1), U17.2 (~CS)
/SolarConditioning/DAC2CS: U15.5 (PB2), U18.2 (~CS)
/SolarConditioning/MISO: U13.12 (Dout), U15.8 (PA5)
/SolarConditioning/MOSI: U13.11 (Din), U15.7 (PA6), U17.4 (SDI), U18.4 (SDI)
/SolarConditioning/MPPT1/A_PWR: D1.1 (K), D9.2 (A); also elsewhere on the board
/SolarConditioning/MPPT1/B_PWR: D2.1 (K), D10.2 (A); also elsewhere on the board
/SolarConditioning/MPPT1/VOUT: Q26.1 (S), Q26.2 (S), Q26.3 (S), R65.1; also elsewhere on the board
/SolarConditioning/MPPT2/A_PWR: D3.1 (K), D11.2 (A); also elsewhere on the board
/SolarConditioning/MPPT2/B_PWR: D4.1 (K), D12.2 (A); also elsewhere on the board
/SolarConditioning/MPPT3/A_PWR: D5.1 (K), D13.2 (A); also elsewhere on the board
/SolarConditioning/MPPT3/B_PWR: D6.1 (K), D14.2 (A); also elsewhere on the board
/SolarConditioning/MPPT4/A_PWR: D7.1 (K), D15.2 (A); also elsewhere on the board
/SolarConditioning/MPPT4/B_PWR: D8.1 (K), D16.2 (A), Q25.1 (S), Q25.2 (S), Q25.3 (S), U12.6 (SENSE); also elsewhere on the board
/SolarConditioning/PANEL_OR: C37.1, D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), U16.8 (IN)
/SolarConditioning/SCK: U13.13 (CLK), U15.9 (PA4), U17.3 (SCK), U18.3 (SCK)
/SolarConditioning/Vset1: U17.8 (VA); also elsewhere on the board
/SolarConditioning/Vset2: U17.6 (VB); also elsewhere on the board
/SolarConditioning/Vset3: U18.8 (VA); also elsewhere on the board
/SolarConditioning/Vset4: U18.6 (VB); also elsewhere on the board
BCR_OUT: R69.1, U14.4 (+), U14.5 (V+); also elsewhere on the board
GND: C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, H5.1, H6.1, H7.1, H8.1, J5.3, J5.4, J6.3, J6.4, J7.3, J7.4, J8.3, J8.4, J9.3, J9.4, J10.3, J10.4, J11.3, J11.4, J12.3, J12.4, J13.7, R68.2, R71.2, SW3.2 (B), U12.2 (GND), U12.3 (CTL), U13.9 (DGND), U13.14 (AGND), U14.2 (V-), U15.14 (GND), U16.2 (GND), U16.3 (GND), U16.6 (GND), U16.7 (GND), U17.7 (Vss), U18.7 (Vss); also elsewhere on the board
I_SA1A: U13.1 (CH0); also elsewhere on the board
I_SA1B: U13.2 (CH1); also elsewhere on the board
I_SA2A: U13.3 (CH2); also elsewhere on the board
I_SA2B: U13.4 (CH3); also elsewhere on the board
I_SA3A: U13.5 (CH4); also elsewhere on the board
I_SA3B: U13.6 (CH5); also elsewhere on the board
I_SA4A: U13.7 (CH6); also elsewhere on the board
I_SA4B: U13.8 (CH7); also elsewhere on the board
unnamed: D1.2 (A), J5.1, J5.2
unnamed: D2.2 (A), J6.1, J6.2
unnamed: D3.2 (A), J7.1, J7.2
unnamed: D4.2 (A), J8.1, J8.2
unnamed: D5.2 (A), J9.1, J9.2
unnamed: D6.2 (A), J10.1, J10.2
unnamed: D7.2 (A), J11.1, J11.2
unnamed: D8.2 (A), J12.1, J12.2
unnamed: Q25.4 (G), U12.5 (GATE)
unnamed: Q26.4 (G), R65.2, R66.1
unnamed: Q26.5 (D), Q26.6 (D), Q26.7 (D), Q26.8 (D), R67.1, R69.2, R70.2
unnamed: R66.2, SW3.1 (A)
unnamed: R70.1, U14.3 (-)
SOLAR_CS0: J13.5; also elsewhere on the board
SOLAR_CS1: J13.6; also elsewhere on the board
SOLAR_MISO: J13.3; also elsewhere on the board
SOLAR_MOSI: J13.4; also elsewhere on the board
SOLAR_SCK: J13.2; also elsewhere on the board
TELEM_IBCROUT: R71.1, U14.1; also elsewhere on the board
TELEM_VBCROUT: R67.2, R68.1; also elsewhere on the board
VUSB: Q25.5 (D), Q25.6 (D), Q25.7 (D), Q25.8 (D), U12.1 (VIN); also elsewhere on the board
V_SA1: U15.13 (AREF/PA0); also elsewhere on the board
V_SA2: U15.12 (PA1); also elsewhere on the board
V_SA3: U15.11 (PA2); also elsewhere on the board
V_SA4: U15.10 (PA3); also elsewhere on the board

Notes on the sheet:
MPPT Setpoint Controller
200mV/A
