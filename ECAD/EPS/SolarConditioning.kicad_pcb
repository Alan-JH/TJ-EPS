# Repository Alan-JH/TJ-EPS (continued)

## KiCad design ECAD/TJ-EPS.kicad_pcb (continued)

Parts:
C60: 1uF; C_0805_2012Metric
C61, C65, C66, C68, C69, C84, C85, C86: 0.1uF; C_0805_2012Metric
C62, C67, C70, C71: 10uF; C_0805_2012Metric
C63, C64, C72, C73, C74, C75, C76, C77, C78, C79, C80, C81, C82, C83: 47uF; C_1812_4532Metric
D26, D27: RB051MM-2Y; D_SOD-123F
L6, L7: 82uH; L_Wuerth_HCI-2212
Q28, Q29: SIR167DP; PowerPAK_SO-8_Single
Q30, Q32, Q34, Q35, Q36, Q39, Q40: 2N7002; SOT-23
Q31, Q33, Q37, Q38: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
R162, R163, R169, R170, R171, R172, R173, R174, R175, R176, R177: 10K; R_0805_2012Metric
R164: 40K; R_0805_2012Metric
R165: 30K; R_0805_2012Metric
R166: 7.5K; R_0805_2012Metric
R167, R168: 15m; R_2010_5025Metric
R178, R181, R182: 10m; R_2010_5025Metric
R179: 9.5K; R_0805_2012Metric
R180: 3K; R_0805_2012Metric
R183, R185: 11K; R_0805_2012Metric
R184, R186: 4K; R_0805_2012Metric
R187: 200K; R_0805_2012Metric
R188, R189, R190, R191, R192: 100K; R_0805_2012Metric
U46: LM358; SO-8_3.9x4.9mm_P1.27mm
U47: LM1117-3.3; SOT-223-3_TabPin2
U48: ADR4530; SOIC-8_3.9x4.9mm_P1.27mm
U49, U50: MAX1626; SO-8_3.9x4.9mm_P1.27mm
U51, U52, U53: MAX4373F; SO-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: R182.1, R191.1, U53.7 (RS-); also elsewhere on the board
+5V: R181.1, R189.1, U52.7 (RS-); also elsewhere on the board
/PowerConditioning/GATE3V3: Q40.1 (G), R175.2, U53.6 (COUT1); also elsewhere on the board
/PowerConditioning/GATE5V: Q39.1 (G), R174.2, U52.6 (COUT1); also elsewhere on the board
/PowerConditioning/GATEBATV: Q34.1 (G), R172.2, U51.6 (COUT1); also elsewhere on the board
/PowerConditioning/PCM_FILT: C62.1, C63.1, C64.1, C68.1, C69.1, C70.1, C71.1, Q31.5 (D), Q31.6 (D), Q31.7 (D), Q31.8 (D), Q33.1 (S), Q33.2 (S), Q33.3 (S), R167.1, R168.1, R169.1, U47.3 (VI), U49.2 (~3~/5), U49.5 (V+), U50.5 (V+)
/PowerConditioning/RST3V3OCP: R177.2, U53.5 (~RESET); also elsewhere on the board
/PowerConditioning/RST3V3PLS: Q36.1 (G); also elsewhere on the board
/PowerConditioning/RST5VOCP: R176.2, U52.5 (~RESET); also elsewhere on the board
/PowerConditioning/RST5VPLS: Q35.1 (G); also elsewhere on the board
/PowerConditioning/RSTBATVOCP: R173.2, U51.5 (~RESET); also elsewhere on the board
/PowerConditioning/RSTBATVPLS: Q32.1 (G); also elsewhere on the board
GND: C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, D26.2 (A), D27.2 (A), Q30.2 (S), Q32.2 (S), Q35.2 (S), Q36.2 (S), R162.2, R163.2, R166.2, R180.2, R184.2, R186.2, R188.2, R190.2, R192.2, U46.4 (V-), U46.5 (+), U47.1 (GND), U48.4 (GND), U49.8 (GND), U50.2 (~3~/5), U50.8 (GND), U51.4 (GND), U52.4 (GND), U53.4 (GND); also elsewhere on the board
unnamed: C65.1, U49.4 (REF)
unnamed: C66.1, U50.4 (REF)
unnamed: C72.1, C73.1, C76.1, C77.1, C80.1, C81.1, L6.2, Q37.1 (S), Q37.2 (S), Q37.3 (S), R170.1, U49.1 (OUT)
unnamed: C74.1, C75.1, C78.1, C79.1, C82.1, C83.1, L7.2, Q38.1 (S), Q38.2 (S), Q38.3 (S), R171.1, U50.1 (OUT)
unnamed: D26.1 (K), L6.1, Q28.5 (D)
unnamed: D27.1 (K), L7.1, Q29.5 (D)
unnamed: Q28.1 (S), Q28.2 (S), Q28.3 (S), R167.2, U49.6 (CS)
unnamed: Q28.4 (G), U49.7 (EXT)
unnamed: Q29.1 (S), Q29.2 (S), Q29.3 (S), R168.2, U50.6 (CS)
unnamed: Q29.4 (G), U50.7 (EXT)
unnamed: Q30.1 (G), Q31.4 (G), U46.1
unnamed: Q30.3 (D), R165.2, R166.1
unnamed: Q32.3 (D), Q34.2 (S)
unnamed: Q33.4 (G), Q34.3 (D), R169.2
unnamed: Q33.5 (D), Q33.6 (D), Q33.7 (D), Q33.8 (D), R178.2, U51.8 (RS+)
unnamed: Q35.3 (D), Q39.2 (S)
unnamed: Q36.3 (D), Q40.2 (S)
unnamed: Q37.4 (G), Q39.3 (D), R170.2
unnamed: Q37.5 (D), Q37.6 (D), Q37.7 (D), Q37.8 (D), R181.2, U52.8 (RS+)
unnamed: Q38.4 (G), Q40.3 (D), R171.2
unnamed: Q38.5 (D), Q38.6 (D), Q38.7 (D), Q38.8 (D), R182.2, U53.8 (RS+)
unnamed: R162.1, U49.3 (SHDN)
unnamed: R163.1, U50.3 (SHDN)
unnamed: R164.2, R165.1, U46.2 (-)
unnamed: R179.2, R180.1, U51.3 (CIN1)
unnamed: R183.2, R184.1, U52.3 (CIN1)
unnamed: R185.2, R186.1, U53.3 (CIN1)
unnamed: U46.3 (+), U48.6 (OUT)
unnamed: U46.6 (-), U46.7
PCM_IN: C60.1, C61.1, Q31.1 (S), Q31.2 (S), Q31.3 (S), R164.1, U46.8 (V+), U48.2 (IN); also elsewhere on the board
TELEM_I3V3: R185.1, U53.2 (OUT); also elsewhere on the board
TELEM_I5V: R183.1, U52.2 (OUT); also elsewhere on the board
TELEM_IBATV: R179.1, U51.2 (OUT); also elsewhere on the board
TELEM_V3V3: R191.2, R192.1; also elsewhere on the board
TELEM_V5V: R189.2, R190.1; also elsewhere on the board
TELEM_VBATV: R187.2, R188.1; also elsewhere on the board
VCC: C67.1, C84.1, C85.1, C86.1, R172.1, R173.1, R174.1, R175.1, R176.1, R177.1, U47.2 (VO), U51.1 (Vcc), U52.1 (Vcc), U53.1 (Vcc); also elsewhere on the board

Notes on the sheet:
Lower resistor provides hysteresis for UVLO Falling threshold, with the mosfet conducting, is 6.2V (6.199 taking into account 7.5 ohm Rds(on)) Rising threshold, with mosfet open, is 7V
UV Active High Compares with a 3V ref
Undervoltage Protection
Battery OCP set to 5A
5V and 3V3 OCP set to 4.5A
5V and 3V3 Buck PCMs
Always On Regulator
BATV PCM (OCP)

Parts:
C97, C98: 0.1uF; C_0805_2012Metric
R310: 10K; R_0805_2012Metric
U62, U63: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C97.1, C98.1, R310.1, U62.16 (VCC), U63.10 (~SRCLR), U63.16 (VCC); also elsewhere on the board
GND: C97.2, C98.2, U62.8 (GND), U62.13 (~OE), U63.8 (GND), U63.13 (~OE); also elsewhere on the board
unnamed: U62.9 (QH'), U63.14 (SER)
PDMRST: R310.2, U62.10 (~SRCLR); also elsewhere on the board
SRCLK: U62.11 (SRCLK), U63.11 (SRCLK); also elsewhere on the board
SRLCH: U62.12 (RCLK), U63.12 (RCLK); also elsewhere on the board
SRSERIN: U62.14 (SER); also elsewhere on the board
SW1: U62.15 (QA); also elsewhere on the board
SW2: U62.1 (QB); also elsewhere on the board
SW3: U62.2 (QC); also elsewhere on the board
SW4: U62.3 (QD); also elsewhere on the board
SW5: U62.4 (QE); also elsewhere on the board
SW6: U62.5 (QF); also elsewhere on the board
SW7: U62.6 (QG); also elsewhere on the board
SW8: U62.7 (QH); also elsewhere on the board
SW9: U63.15 (QA); also elsewhere on the board
SW10: U63.1 (QB); also elsewhere on the board
SW11: U63.2 (QC); also elsewhere on the board
SW12: U63.3 (QD); also elsewhere on the board

Notes on the sheet:
BAT PDMs
5V PDMs
3.3V PDMs
PDM Control SRs

Parts:
C34: 0.1uF; C_0805_2012Metric
Q22: 2N7002; SOT-23
Q23: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
Q24: Si4186DY; SOIC-8_3.9x4.9mm_P1.27mm
R58, R61: 100R; R_0805_2012Metric
R59, R60, R62: 10K; R_0805_2012Metric
R63: Heater (125R); PinHeader_1x02_P2.54mm_Vertical
R64: 270K; R_0805_2012Metric
TH5: 100K NTC; PinHeader_1x02_P2.54mm_Vertical

Connections:
+3V3: R64.1; also elsewhere on the board
+5V: Q23.1 (S), Q23.2 (S), Q23.3 (S), R60.1; also elsewhere on the board
/Battery/H1BOT: R61.2; also elsewhere on the board
/Battery/H1TOP: R58.2; also elsewhere on the board
/Battery/TBAT1: C34.1, R64.2, TH5.1; also elsewhere on the board
GND: C34.2, Q22.2 (S), Q24.1 (S), Q24.2 (S), Q24.3 (S), R59.2, R62.2, TH5.2; also elsewhere on the board
unnamed: Q22.1 (G), R58.1, R59.1
unnamed: Q22.3 (D), Q23.4 (G), R60.2
unnamed: Q23.5 (D), Q23.6 (D), Q23.7 (D), Q23.8 (D), R63.1
unnamed: Q24.4 (G), R61.1, R62.1
unnamed: Q24.5 (D), Q24.6 (D), Q24.7 (D), Q24.8 (D), R63.2

Parts of its further copies:
C31, C32, C33: 0.1uF; C_0805_2012Metric
Q13, Q16, Q19: 2N7002; SOT-23
Q14, Q17, Q20: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
Q15, Q18, Q21: Si4186DY; SOIC-8_3.9x4.9mm_P1.27mm
R37, R40, R44, R47, R51, R54: 100R; R_0805_2012Metric
R38, R39, R41, R45, R46, R48, R52, R53, R55: 10K; R_0805_2012Metric
R42, R49, R56: Heater (125R); PinHeader_1x02_P2.54mm_Vertical
R43, R50, R57: 270K; R_0805_2012Metric
TH2, TH3, TH4: 100K NTC; PinHeader_1x02_P2.54mm_Vertical

Connections of its further copies:
+3V3: R43.1, R50.1, R57.1; also elsewhere on the board
+5V: Q14.1 (S), Q14.2 (S), Q14.3 (S), Q17.1 (S), Q17.2 (S), Q17.3 (S), Q20.1 (S), Q20.2 (S), Q20.3 (S), R39.1, R46.1, R53.1; also elsewhere on the board
/Battery/H2BOT: R40.2; also elsewhere on the board
/Battery/H2TOP: R37.2; also elsewhere on the board
/Battery/H3BOT: R47.2; also elsewhere on the board
/Battery/H3TOP: R44.2; also elsewhere on the board
/Battery/H4BOT: R54.2; also elsewhere on the board
/Battery/H4TOP: R51.2; also elsewhere on the board
/Battery/TBAT2: C31.1, R43.2, TH2.1; also elsewhere on the board
/Battery/TBAT3: C32.1, R50.2, TH3.1; also elsewhere on the board
/Battery/TBAT4: C33.1, R57.2, TH4.1; also elsewhere on the board
GND: C31.2, C32.2, C33.2, Q13.2 (S), Q15.1 (S), Q15.2 (S), Q15.3 (S), Q16.2 (S), Q18.1 (S), Q18.2 (S), Q18.3 (S), Q19.2 (S), Q21.1 (S), Q21.2 (S), Q21.3 (S), R38.2, R41.2, R45.2, R48.2, R52.2, R55.2, TH2.2, TH3.2, TH4.2; also elsewhere on the board
unnamed: Q13.1 (G), R37.1, R38.1
unnamed: Q13.3 (D), Q14.4 (G), R39.2
unnamed: Q14.5 (D), Q14.6 (D), Q14.7 (D), Q14.8 (D), R42.1
unnamed: Q15.4 (G), R40.1, R41.1
unnamed: Q15.5 (D), Q15.6 (D), Q15.7 (D), Q15.8 (D), R42.2
unnamed: Q16.1 (G), R44.1, R45.1
unnamed: Q16.3 (D), Q17.4 (G), R46.2
unnamed: Q17.5 (D), Q17.6 (D), Q17.7 (D), Q17.8 (D), R49.1
unnamed: Q18.4 (G), R47.1, R48.1
unnamed: Q18.5 (D), Q18.6 (D), Q18.7 (D), Q18.8 (D), R49.2
unnamed: Q19.1 (G), R51.1, R52.1
unnamed: Q19.3 (D), Q20.4 (G), R53.2
unnamed: Q20.5 (D), Q20.6 (D), Q20.7 (D), Q20.8 (D), R56.1
unnamed: Q21.4 (G), R54.1, R55.1
unnamed: Q21.5 (D), Q21.6 (D), Q21.7 (D), Q21.8 (D), R56.2

Notes on the sheet:
Top resistor selected for 5C center operating temperature

Parts:
C47, C49: 10uF; C_0805_2012Metric
C48: 1uF; C_0805_2012Metric
D21: CMSH3-40MA; D_SMA
D22: RB051MM-2Y; D_SOD-123F
L3: 22uH; L_Bourns_SRP7028A_7.3x6.6mm
R100, R101: 50R; R_0805_2012Metric
R102, R103: 20m; R_2512_6332Metric
R104, R105: 5K; R_0805_2012Metric
R106: 750K; R_0805_2012Metric
R107: 100K; R_0805_2012Metric
R108: 1K; R_0805_2012Metric
R109: 7.5K; R_0805_2012Metric
R110: 52.8K; R_0805_2012Metric
R111: 490K; R_0805_2012Metric
R112: 330K; R_0805_2012Metric
R113: 50m; R_2512_6332Metric
U27, U28: LT6106; SOT-23-5
U29: LM358; SO-8_3.9x4.9mm_P1.27mm
U30: LT3652EMSE; MSOP-12-1EP_3x4mm_P0.65mm_EP1.65x2.85mm

Connections:
/SolarConditioning/MPPT1/A_PWR: R100.1, R102.2; also elsewhere on the board
/SolarConditioning/MPPT1/B_PWR: R101.1, R103.2; also elsewhere on the board
/SolarConditioning/MPPT1/VOUT: C49.1, D22.2 (A), R111.2, R113.1, U30.9 (BAT); also elsewhere on the board
/SolarConditioning/Vset1: U29.3 (+); also elsewhere on the board
GND: C47.2, C49.2, D21.2 (A), R104.2, R105.2, R107.2, R108.2, R112.1, U27.2 (V-), U28.2 (V-), U29.4 (V-), U30.6 (TIMER), U30.13 (GND); also elsewhere on the board
I_SA1A: R104.1, U27.1; also elsewhere on the board
I_SA1B: R105.1, U28.1; also elsewhere on the board
unnamed: C47.1, R102.1, R103.1, R106.1, U27.4 (+), U27.5 (V+), U28.4 (+), U28.5 (V+), U29.5 (+), U29.8 (V+), U30.1 (VIN), U30.3 (~SHDN)
unnamed: C48.1, D21.1 (K), L3.1, U30.12 (SW)
unnamed: C48.2, D22.1 (K), U30.11 (BOOST)
unnamed: L3.2, R113.2, U30.10 (SENSE)
unnamed: R100.2, U27.3 (-)
unnamed: R101.2, U28.3 (-)
unnamed: R108.1, R109.2, U29.2 (-)
unnamed: R109.1, U29.1, U29.6 (-)
unnamed: R110.1, R111.1, R112.2
unnamed: R110.2, U30.7 (VFB)
unnamed: U29.7, U30.2 (VIN_REG)
V_SA1: R106.2, R107.1; also elsewhere on the board

Parts of its further copies:
C41, C43, C44, C46: 10uF; C_0805_2012Metric
C42, C45: 1uF; C_0805_2012Metric
D17, D19: CMSH3-40MA; D_SMA
D18, D20: RB051MM-2Y; D_SOD-123F
L1, L2: 22uH; L_Bourns_SRP7028A_7.3x6.6mm
R72, R73, R86, R87: 50R; R_0805_2012Metric
R74, R75, R88, R89: 20m; R_2512_6332Metric
R76, R77, R90, R91: 5K; R_0805_2012Metric
R78, R92: 750K; R_0805_2012Metric
R79, R93: 100K; R_0805_2012Metric
R80, R94: 1K; R_0805_2012Metric
R81, R95: 7.5K; R_0805_2012Metric
R82, R96: 52.8K; R_0805_2012Metric
R83, R97: 490K; R_0805_2012Metric
R84, R98: 330K; R_0805_2012Metric
R85, R99: 50m; R_2512_6332Metric
U19, U20, U23, U24: LT6106; SOT-23-5
U21, U25: LM358; SO-8_3.9x4.9mm_P1.27mm
U22, U26: LT3652EMSE; MSOP-12-1EP_3x4mm_P0.65mm_EP1.65x2.85mm

Connections of its further copies:
/SolarConditioning/MPPT1/VOUT: C43.1, C46.1, D18.2 (A), D20.2 (A), R83.2, R85.1, R97.2, R99.1, U22.9 (BAT), U26.9 (BAT); also elsewhere on the board
/SolarConditioning/MPPT2/A_PWR: R86.1, R88.2; also elsewhere on the board
/SolarConditioning/MPPT2/B_PWR: R87.1, R89.2; also elsewhere on the board
/SolarConditioning/MPPT3/A_PWR: R72.1, R74.2; also elsewhere on the board
/SolarConditioning/MPPT3/B_PWR: R73.1, R75.2; also elsewhere on the board
/SolarConditioning/Vset2: U25.3 (+); also elsewhere on the board
/SolarConditioning/Vset3: U21.3 (+); also elsewhere on the board
GND: C41.2, C43.2, C44.2, C46.2, D17.2 (A), D19.2 (A), R76.2, R77.2, R79.2, R80.2, R84.1, R90.2, R91.2, R93.2, R94.2, R98.1, U19.2 (V-), U20.2 (V-), U21.4 (V-), U22.6 (TIMER), U22.13 (GND), U23.2 (V-), U24.2 (V-), U25.4 (V-), U26.6 (TIMER), U26.13 (GND); also elsewhere on the board
I_SA2A: R90.1, U23.1; also elsewhere on the board
I_SA2B: R91.1, U24.1; also elsewhere on the board
I_SA3A: R76.1, U19.1; also elsewhere on the board
I_SA3B: R77.1, U20.1; also elsewhere on the board
unnamed: C41.1, R74.1, R75.1, R78.1, U19.4 (+), U19.5 (V+), U20.4 (+), U20.5 (V+), U21.5 (+), U21.8 (V+), U22.1 (VIN), U22.3 (~SHDN)
unnamed: C42.1, D17.1 (K), L1.1, U22.12 (SW)
unnamed: C42.2, D18.1 (K), U22.11 (BOOST)
unnamed: C44.1, R88.1, R89.1, R92.1, U23.4 (+), U23.5 (V+), U24.4 (+), U24.5 (V+), U25.5 (+), U25.8 (V+), U26.1 (VIN), U26.3 (~SHDN)
unnamed: C45.1, D19.1 (K), L2.1, U26.12 (SW)
unnamed: C45.2, D20.1 (K), U26.11 (BOOST)
unnamed: L1.2, R85.2, U22.10 (SENSE)
unnamed: L2.2, R99.2, U26.10 (SENSE)
unnamed: R72.2, U19.3 (-)
unnamed: R73.2, U20.3 (-)
unnamed: R80.1, R81.2, U21.2 (-)
unnamed: R81.1, U21.1, U21.6 (-)
unnamed: R82.1, R83.1, R84.2
unnamed: R82.2, U22.7 (VFB)
unnamed: R86.2, U23.3 (-)
unnamed: R87.2, U24.3 (-)
unnamed: R94.1, R95.2, U25.2 (-)
unnamed: R95.1, U25.1, U25.6 (-)
unnamed: R96.1, R97.1, R98.2
unnamed: R96.2, U26.7 (VFB)
unnamed: U21.7, U22.2 (VIN_REG)
unnamed: U25.7, U26.2 (VIN_REG)
V_SA2: R92.2, R93.1; also elsewhere on the board
V_SA3: R78.2, R79.1; also elsewhere on the board

Notes on the sheet:
Float voltage selection Rbottom/Rtop = 3.3/(Vbat - 3.3) Rmiddle = 250K - Rtop || Rbottom
Gain = Rout/Rin = 100 2V/A
Input Current Telemetry
Input Voltage Telemetry and Vmp Setpoint
Buck Converter and Charge Profile
Imax = 0.1V/Rsense Maximum allowed is 2A Termination at C/10 = 0.2A

Parts:
C50, C54: 10uF; C_0805_2012Metric
C51: 0.1uF; C_0805_2012Metric
C52: 1uF; C_0805_2012Metric
C53: 0.01uF; C_0805_2012Metric
C55, C56, C57: 22uF; C_2220_5650Metric
D23, D25: CMSH3-40MA; D_SMA
D24: RB051MM-2Y; D_SOD-123F
L4: 22uH; L_Bourns_SRP7028A_7.3x6.6mm
L5: 47uH; L_Bourns_SRR1260
Q27: Si4186DY; SOIC-8_3.9x4.9mm_P1.27mm
R114, R115: 50R; R_0805_2012Metric
R116, R117: 20m; R_2512_6332Metric
R118: 1K; R_0805_2012Metric
R119: 7.5K; R_0805_2012Metric
R120, R121: 5K; R_0805_2012Metric
R122: 400K; R_0805_2012Metric
R123, R124: 100K; R_0805_2012Metric
R125: 52.8K; R_0805_2012Metric
R126: 490K; R_0805_2012Metric
R127: 330K; R_0805_2012Metric
R128: 50m; R_2512_6332Metric
R129: 24R; R_0805_2012Metric
U31: LM358; SO-8_3.9x4.9mm_P1.27mm
U32, U33: LT6106; SOT-23-5
U34: LT3652EMSE; MSOP-12-1EP_3x4mm_P0.65mm_EP1.65x2.85mm
U35: LMC555xM; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/SolarConditioning/MPPT1/VOUT: C54.1, D24.2 (A), R126.2, R128.1, U34.9 (BAT); also elsewhere on the board
/SolarConditioning/MPPT4/A_PWR: R114.1, R116.2; also elsewhere on the board
/SolarConditioning/MPPT4/B_PWR: R115.1, R117.2; also elsewhere on the board
/SolarConditioning/MPPT4/VBOOST: C50.1, C56.1, C57.1, D25.1 (K), U31.5 (+), U31.8 (V+), U34.1 (VIN), U34.3 (~SHDN)
/SolarConditioning/Vset4: U31.3 (+); also elsewhere on the board
GND: C50.2, C51.2, C53.2, C54.2, C55.2, C56.2, C57.2, D23.2 (A), Q27.1 (S), Q27.2 (S), Q27.3 (S), R118.2, R120.2, R121.2, R123.2, R127.1, U31.4 (V-), U32.2 (V-), U33.2 (V-), U34.6 (TIMER), U34.13 (GND), U35.1 (GND); also elsewhere on the board
I_SA4A: R120.1, U32.1; also elsewhere on the board
I_SA4B: R121.1, U33.1; also elsewhere on the board
unnamed: C51.1, R124.2, R129.1, U35.2 (TR), U35.6 (THR)
unnamed: C52.1, D23.1 (K), L4.1, U34.12 (SW)
unnamed: C52.2, D24.1 (K), U34.11 (BOOST)
unnamed: C53.1, U35.5 (CV)
unnamed: C55.1, L5.1, R116.1, R117.1, R122.1, R124.1, U32.4 (+), U32.5 (V+), U33.4 (+), U33.5 (V+), U35.4 (R), U35.8 (VCC)
unnamed: D25.2 (A), L5.2, Q27.5 (D), Q27.6 (D), Q27.7 (D), Q27.8 (D)
unnamed: L4.2, R128.2, U34.10 (SENSE)
unnamed: Q27.4 (G), R129.2, U35.3 (Q)
unnamed: R114.2, U32.3 (-)
unnamed: R115.2, U33.3 (-)
unnamed: R118.1, R119.2, U31.2 (-)
unnamed: R119.1, U31.1, U31.6 (-)
unnamed: R125.1, R126.1, R127.2
unnamed: R125.2, U34.7 (VFB)
unnamed: U31.7, U34.2 (VIN_REG)
V_SA4: R122.2, R123.1; also elsewhere on the board

Notes on the sheet:
Gain = Rout/Rin = 100 2V/A
Input Current Telemetry
Imax = 0.1V/Rsense Maximum allowed is 2A Termination at C/10 = 0.2A
Buck Converter and Charge Profile
Vmp Setpoint
Float voltage selection Rbottom/Rtop = 3.3/(Vbat - 3.3) Rmiddle = 250K - Rtop || Rbottom
2x Boost conversion + Input Voltage telemetry

Schematic: SolarTelem.sch, TJ Custom EPS

Parts:
C58, C59: 0.1uF; C_0805_2012Metric
H9, H10, H11, H12: M2.5; MountingHole_2.7mm_M2.5_DIN965_Pad
J14: S1A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J15: S1B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J16: S2A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J17: S2B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J18: S3A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J19: S3B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J20: S4A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J21: S4B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J22: OUT; PinSocket_1x07_P1.27mm_Vertical
U36, U37: MCP3208; SO-16_3.9x9.9mm_P1.27mm

Connections:
+3.3VA: C58.1, C59.1, J22.1, U36.15 (Vref), U36.16 (Vdd), U37.15 (Vref), U37.16 (Vdd); also elsewhere on the board
/SolarConditioning/SolarTelem/CS0: J22.5, U36.10 (~CS~/SHDN)
/SolarConditioning/SolarTelem/CS1: J22.6, U37.10 (~CS~/SHDN)
/SolarConditioning/SolarTelem/MISO: J22.3, U36.12 (Dout), U37.12 (Dout)
/SolarConditioning/SolarTelem/MOSI: J22.4, U36.11 (Din), U37.11 (Din)
/SolarConditioning/SolarTelem/S1ATelem/PHOTOIN: J14.3; also elsewhere on the board
/SolarConditioning/SolarTelem/S1ATelem/PHOTOOUT: U36.2 (CH1); also elsewhere on the board
/SolarConditioning/SolarTelem/S1ATelem/TEMPIN: J14.2; also elsewhere on the board
/SolarConditioning/SolarTelem/S1ATelem/TEMPOUT: U36.1 (CH0); also elsewhere on the board
/SolarConditioning/SolarTelem/S1BTelem/PHOTOIN: J15.3; also elsewhere on the board
/SolarConditioning/SolarTelem/S1BTelem/PHOTOOUT: U36.4 (CH3); also elsewhere on the board
/SolarConditioning/SolarTelem/S1BTelem/TEMPIN: J15.2; also elsewhere on the board
/SolarConditioning/SolarTelem/S1BTelem/TEMPOUT: U36.3 (CH2); also elsewhere on the board
/SolarConditioning/SolarTelem/S2ATelem/PHOTOIN: J16.3; also elsewhere on the board
/SolarConditioning/SolarTelem/S2ATelem/PHOTOOUT: U36.6 (CH5); also elsewhere on the board
/SolarConditioning/SolarTelem/S2ATelem/TEMPIN: J16.2; also elsewhere on the board
/SolarConditioning/SolarTelem/S2ATelem/TEMPOUT: U36.5 (CH4); also elsewhere on the board
/SolarConditioning/SolarTelem/S2BTelem/PHOTOIN: J17.3; also elsewhere on the board
/SolarConditioning/SolarTelem/S2BTelem/PHOTOOUT: U36.8 (CH7); also elsewhere on the board
/SolarConditioning/SolarTelem/S2BTelem/TEMPIN: J17.2; also elsewhere on the board
/SolarConditioning/SolarTelem/S2BTelem/TEMPOUT: U36.7 (CH6); also elsewhere on the board
/SolarConditioning/SolarTelem/S3ATelem/PHOTOIN: J18.3; also elsewhere on the board
/SolarConditioning/SolarTelem/S3ATelem/PHOTOOUT: U37.2 (CH1); also elsewhere on the board
/SolarConditioning/SolarTelem/S3ATelem/TEMPIN: J18.2; also elsewhere on the board
/SolarConditioning/SolarTelem/S3ATelem/TEMPOUT: U37.1 (CH0); also elsewhere on the board
/SolarConditioning/SolarTelem/S3BTelem/PHOTOIN: J19.3; also elsewhere on the board
/SolarConditioning/SolarTelem/S3BTelem/PHOTOOUT: U37.4 (CH3); also elsewhere on the board
/SolarConditioning/SolarTelem/S3BTelem/TEMPIN: J19.2; also elsewhere on the board
/SolarConditioning/SolarTelem/S3BTelem/TEMPOUT: U37.3 (CH2); also elsewhere on the board
/SolarConditioning/SolarTelem/S4ATelem/PHOTOIN: J20.3; also elsewhere on the board
/SolarConditioning/SolarTelem/S4ATelem/PHOTOOUT: U37.6 (CH5); also elsewhere on the board
/SolarConditioning/SolarTelem/S4ATelem/TEMPIN: J20.2; also elsewhere on the board
/SolarConditioning/SolarTelem/S4ATelem/TEMPOUT: U37.5 (CH4); also elsewhere on the board
/SolarConditioning/SolarTelem/S4BTelem/PHOTOIN: J21.3; also elsewhere on the board
/SolarConditioning/SolarTelem/S4BTelem/PHOTOOUT: U37.8 (CH7); also elsewhere on the board
/SolarConditioning/SolarTelem/S4BTelem/TEMPIN: J21.2; also elsewhere on the board
/SolarConditioning/SolarTelem/S4BTelem/TEMPOUT: U37.7 (CH6); also elsewhere on the board
/SolarConditioning/SolarTelem/SCK: J22.2, U36.13 (CLK), U37.13 (CLK)
GND: C58.2, C59.2, H9.1, H10.1, H11.1, H12.1, J22.7, U36.9 (DGND), U36.14 (AGND), U37.9 (DGND), U37.14 (AGND); also elsewhere on the board
unnamed: J14.1, J14.4
unnamed: J15.1, J15.4
unnamed: J16.1, J16.4
unnamed: J17.1, J17.4
unnamed: J18.1, J18.4
unnamed: J19.1, J19.4
unnamed: J20.1, J20.4
unnamed: J21.1, J21.4

Schematic: Pulse+RetryTimer.sch, TJ Custom EPS

Parts:
C87: 22uF; C_0805_2012Metric
C90: 0.1uF; C_0805_2012Metric
Q41, Q42: 2N7002; SOT-23
R193: 2.5M; R_0805_2012Metric
R194, R205: 10K; R_0805_2012Metric
R195: 20K; R_0805_2012Metric
R203: 523R; R_0805_2012Metric
R204: 1K; R_0805_2012Metric
R206: 760K; R_0805_2012Metric
U54: AD8603; TSOT-23-5
U57: LTC6993xS6-4; TSOT-23-6

Connections:
/PowerConditioning/GATEBATV: Q41.1 (G); also elsewhere on the board
/PowerConditioning/RST5VPLS: U57.6 (OUT); also elsewhere on the board
/PowerConditioning/RSTBATVOCP: Q42.3 (D); also elsewhere on the board
GND: C87.2, C90.2, Q41.2 (S), Q42.2 (S), R195.2, R204.2, R206.2, U54.2 (V-), U57.2 (GND); also elsewhere on the board
unnamed: C87.1, Q41.3 (D), R193.2, U54.3 (+)
unnamed: Q42.1 (G), U54.1
unnamed: R194.2, R195.1, U54.4 (-)
unnamed: R203.2, R204.1, U57.4 (DIV)
unnamed: R206.1, U57.3 (SET)
RST5V: R205.2, U57.1 (TRIG); also elsewhere on the board
VCC: C90.1, R193.1, R194.1, R203.1, R205.1, U54.5 (V+), U57.5 (V+); also elsewhere on the board

Parts of its further copies:
C88, C92: 0.1uF; C_0805_2012Metric
C89, C91: 22uF; C_0805_2012Metric
Q43, Q44, Q45, Q46: 2N7002; SOT-23
R196, R210: 523R; R_0805_2012Metric
R197, R211: 1K; R_0805_2012Metric
R198, R201, R208, R212: 10K; R_0805_2012Metric
R199, R213: 760K; R_0805_2012Metric
R200, R207: 2.5M; R_0805_2012Metric
R202, R209: 20K; R_0805_2012Metric
U55, U59: LTC6993xS6-4; TSOT-23-6
U56, U58: AD8603; TSOT-23-5

Connections of its further copies:
/PowerConditioning/GATE3V3: Q45.1 (G); also elsewhere on the board
/PowerConditioning/GATE5V: Q43.1 (G); also elsewhere on the board
/PowerConditioning/RST3V3OCP: Q46.3 (D); also elsewhere on the board
/PowerConditioning/RST3V3PLS: U59.6 (OUT); also elsewhere on the board
/PowerConditioning/RST5VOCP: Q44.3 (D); also elsewhere on the board
/PowerConditioning/RSTBATVPLS: U55.6 (OUT); also elsewhere on the board
GND: C88.2, C89.2, C91.2, C92.2, Q43.2 (S), Q44.2 (S), Q45.2 (S), Q46.2 (S), R197.2, R199.2, R202.2, R209.2, R211.2, R213.2, U55.2 (GND), U56.2 (V-), U58.2 (V-), U59.2 (GND); also elsewhere on the board
unnamed: C89.1, Q43.3 (D), R200.2, U56.3 (+)
unnamed: C91.1, Q45.3 (D), R207.2, U58.3 (+)
unnamed: Q44.1 (G), U56.1
unnamed: Q46.1 (G), U58.1
unnamed: R196.2, R197.1, U55.4 (DIV)
unnamed: R199.1, U55.3 (SET)
unnamed: R201.2, R202.1, U56.4 (-)
unnamed: R208.2, R209.1, U58.4 (-)
unnamed: R210.2, R211.1, U59.4 (DIV)
unnamed: R213.1, U59.3 (SET)
RST3V3: R212.2, U59.1 (TRIG); also elsewhere on the board
RSTBATV: R198.2, U55.1 (TRIG); also elsewhere on the board
VCC: C88.1, C92.1, R196.1, R198.1, R200.1, R201.1, R207.1, R208.1, R210.1, R212.1, U55.5 (V+), U56.5 (V+), U58.5 (V+), U59.5 (V+); also elsewhere on the board

Notes on the sheet:
t=1.1RC Nominal 60s between retries
See datasheet Set to 0.49152s, Active low output, falling edge input

Schematic: PDM3V3.sch, TJ Custom EPS

Parts:
D31: 1N4004; D_SMA
Q53: 2N7002; SOT-23
Q54: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
R238, R244: 100R; R_0805_2012Metric
R239, R240: 10K; R_0805_2012Metric
R241, R242: 100K; R_0805_2012Metric
R243: 10m; R_2010_5025Metric
R245: 2K; R_0805_2012Metric
U67: LT6106; SOT-23-5

Connections:
+3V3: Q54.5 (D), Q54.6 (D), Q54.7 (D), Q54.8 (D), R240.1; also elsewhere on the board
GND: D31.2 (A), Q53.2 (S), R239.2, R242.2, R245.2, U67.2 (V-); also elsewhere on the board
unnamed: D31.1 (K), Q54.1 (S), Q54.2 (S), Q54.3 (S), R241.1, R243.2, R244.2, U67.5 (V+)
unnamed: Q53.1 (G), R238.1, R239.1
unnamed: Q53.3 (D), Q54.4 (G), R240.2
unnamed: R244.1, U67.3 (-)
SW9: R243.1, U67.4 (+); also elsewhere on the board
TELEM_ISW9: R245.1, U67.1; also elsewhere on the board
TELEM_VSW9: R241.2, R242.1; also elsewhere on the board

Parts of its further copies:
D28, D29, D30: 1N4004; D_SMA
Q47, Q49, Q51: 2N7002; SOT-23
Q48, Q50, Q52: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
R214, R220, R222, R228, R230, R236: 100R; R_0805_2012Metric
R215, R216, R223, R224, R231, R232: 10K; R_0805_2012Metric
R217, R218, R225, R226, R233, R234: 100K; R_0805_2012Metric
R219, R227, R235: 10m; R_2010_5025Metric
R221, R229, R237: 2K; R_0805_2012Metric
U64, U65, U66: LT6106; SOT-23-5

Connections of its further copies:
+3V3: Q48.5 (D), Q48.6 (D), Q48.7 (D), Q48.8 (D), Q50.5 (D), Q50.6 (D), Q50.7 (D), Q50.8 (D), Q52.5 (D), Q52.6 (D), Q52.7 (D), Q52.8 (D), R216.1, R224.1, R232.1; also elsewhere on the board
GND: D28.2 (A), D29.2 (A), D30.2 (A), Q47.2 (S), Q49.2 (S), Q51.2 (S), R215.2, R218.2, R221.2, R223.2, R226.2, R229.2, R231.2, R234.2, R237.2, U64.2 (V-), U65.2 (V-), U66.2 (V-); also elsewhere on the board
unnamed: D28.1 (K), Q48.1 (S), Q48.2 (S), Q48.3 (S), R217.1, R219.2, R220.2, U64.5 (V+)
unnamed: D29.1 (K), Q50.1 (S), Q50.2 (S), Q50.3 (S), R225.1, R227.2, R228.2, U65.5 (V+)
unnamed: D30.1 (K), Q52.1 (S), Q52.2 (S), Q52.3 (S), R233.1, R235.2, R236.2, U66.5 (V+)
unnamed: Q47.1 (G), R214.1, R215.1
unnamed: Q47.3 (D), Q48.4 (G), R216.2
unnamed: Q49.1 (G), R222.1, R223.1
unnamed: Q49.3 (D), Q50.4 (G), R224.2
unnamed: Q51.1 (G), R230.1, R231.1
unnamed: Q51.3 (D), Q52.4 (G), R232.2
unnamed: R220.1, U64.3 (-)
unnamed: R228.1, U65.3 (-)
unnamed: R236.1, U66.3 (-)
SW10: R235.1, U66.4 (+); also elsewhere on the board
SW11: R219.1, U64.4 (+); also elsewhere on the board
SW12: R227.1, U65.4 (+); also elsewhere on the board
TELEM_ISW10: R237.1, U66.1; also elsewhere on the board
TELEM_ISW11: R221.1, U64.1; also elsewhere on the board
TELEM_ISW12: R229.1, U65.1; also elsewhere on the board
TELEM_VSW10: R233.2, R234.1; also elsewhere on the board
TELEM_VSW11: R217.2, R218.1; also elsewhere on the board
TELEM_VSW12: R225.2, R226.1; also elsewhere on the board

Notes on the sheet:
200mV/A
