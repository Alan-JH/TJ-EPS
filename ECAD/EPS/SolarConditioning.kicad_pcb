# Repository Alan-JH/TJ-EPS

File README.md:

# TJ-EPS
Custom Battery and EPS for 2-3U Cubesat. Designed to be versatile, and to be implemented on TJ-iSPIN

Heavily inspired by the Clydespace 3G EPS, but not as expensive, and with some improvements.

## Battery
2P2S setup with 3500mAh 18650 Li-Ion cells. Voltage range from 6 to 8.4V.

Series charge balancing using BQ29209

2 Inhibits (1x ground disconnect, 1x positive disconnect)

7A Polyfuse, 8.4V input OVP, 8A Bidirectional momentary OCP/SCP

Ideal Diode with two more positive disconnect inhibits to EPS regulator input, UVP which disconnects at 6.2V falling and re-enables at 7V

One positive disconnect inhibit between EPS charge output and battery

Battery heaters and temperature telemetry to keep them above 0 deg C

Telemetry IC including Voltage, Current, SOC Charge Integration, Temperatures, and Heater control. Watchdog timer to prevent latchup.

## EPS
VBAT, 5V, 3.3V bus outputs, each with latching current limit (3A, 3A, and 5A respectively), voltage and current telemetry.

10 switchable voltage outputs, each with current and voltage telemetry, with voltage selectable between 3.3V, 5V, and BATV by jumper

Telemetry IC including all voltage and current telemetry, board temperature telemetry, and solar regulator telemetry. Watchdog timer to prevent latchup.

#### Solar Daughterboard
Daughterboard which attaches on top of the main EPS stack board.

4 solar input maximum power point tracking regulators, with two connectors each (intended for panels on opposite sides of the satellite or panels guaranteed equal sunlight).

Solar input range from 9V to 26V. Includes series diode protection on each connector. LT3652 regulators each provide up to 2A battery charging output, with 8.27V float voltage. 

Maximum power point tracking voltage settable by trim potentiometer (MUST BE SET BEFORE LAUNCH)

Input current telemetry for each individual connector, input voltage telemetry for each regulator, and output voltage and current telemetry.

## Component selection
Most components are AEC-Q100/Q101/Q200 Automotive qualified. A few important components are not, by necessity due to the chip shortage. Battery cells must be tested in house, but should be selected by brands commonly used in cubesats such as LG and Panasonic. The boards are to be tested with vibration, and vacuum with temperature cycle individually.

## KiCad design ECAD/EPS/SolarConditioning.kicad_pcb

Board: 2 copper layers, 85.2 x 74.4 mm, 126 parts (0 on the bottom side), 69 nets.

Parts:
C1, C2, C3, C4, C5, C9, C10, C14, C15, C19, C20: 0.1uF; C_0805_2012Metric
C6, C8, C11, C13, C16, C18, C21, C23: 10uF; C_0805_2012Metric
C7, C12, C17, C22: 1uF; C_0805_2012Metric
C24, C25, C26, C27: 22uF; C_1210_3225Metric
D1, D2, D3, D4, D5, D6, D7, D8: SS34FA; D_SOD-123F
D9, D11, D13, D15, D17: CMSH3-40MA; D_SMA
D10, D12, D14, D16: RB051MM-2Y; D_SOD-123F
J1: S1A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J2: S1B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J3: S2A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J4: S2B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J5: S3A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J6: S3B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J7: S4A; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J8: S4B; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J9: Solar Daughterboard Connector; PinHeader_2x05_P2.54mm_Vertical
J10: USBCHG; Hirose_DF13-02P-1.25DSA_1x02_P1.25mm_Vertical
L1, L2, L3, L4: 10uH; L_AVX_LMLP07A7
L5: 33uH; L_Coilcraft_XAL60xx_6.36x6.56mm
MH1, MH2, MH3, MH4, MH5: M2; MountingHole_2.2mm_M2
R1: 200K; R_0805_2012Metric
R2: 100K; R_0805_2012Metric
R3, R4, R5, R12, R13, R20, R21, R28, R29: 4m; R_1206_3216Metric
R6, R14, R22, R30: 75K; R_0805_2012Metric
R7, R15, R23, R31: 10K; R_0805_2012Metric
R8, R16, R24, R32: 191K; R_0805_2012Metric
R9, R17, R25, R33: 147K; R_0805_2012Metric
R10, R18, R26, R34: 97.6K; R_0805_2012Metric
R11, R19, R27, R35: 50m; R_1206_3216Metric
RV1, RV2, RV3, RV4: 100K; Bourns PVG3A
TP1, TP3, TP5, TP7: VIN; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
TP2, TP4, TP6, TP8: Vmpp; TestPoint_Pad_2.0x2.0mm
U1, U3, U4, U6, U7, U9, U10, U12, U13: INA180A3; SOT-23-5
U2: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm
U5, U8, U11, U14: LT3652EMSE; MSOP-12-1EP_3x4mm_P0.65mm_EP1.65x2.85mm
U15: LT1301; SO-8_3.9x4.9mm_P1.27mm

Connections:
/5VIN: C24.1, C25.1, J10.2, L5.1, U15.2 (SEL), U15.6 (VIN)
/MPPT1/A_PWR: D1.1 (K), R4.2, U3.3 (+)
/MPPT1/B_PWR: D2.1 (K), R5.2, U4.3 (+)
/MPPT1/VOUT: C8.1, C13.1, C18.1, C23.1, D10.2 (A), D12.2 (A), D14.2 (A), D16.2 (A), R1.1, R3.2, R9.2, R11.1, R17.2, R19.1, R25.2, R27.1, R33.2, R35.1, U1.3 (+), U5.9 (BAT), U8.9 (BAT), U11.9 (BAT), U14.9 (BAT)
/MPPT2/A_PWR: D3.1 (K), R12.2, U6.3 (+)
/MPPT2/B_PWR: D4.1 (K), R13.2, U7.3 (+)
/MPPT3/A_PWR: D5.1 (K), R20.2, U9.3 (+)
/MPPT3/B_PWR: D6.1 (K), R21.2, U10.3 (+)
/MPPT4/A_PWR: D7.1 (K), R28.2, U12.3 (+)
/MPPT4/B_PWR: C26.1, C27.1, D8.1 (K), D17.1 (K), R29.2, U13.3 (+), U15.4 (SENSE)
BCR_OUT: J9.7, J9.8, R3.1, U1.4 (-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C21.2, C23.2, C24.2, C25.2, C26.2, C27.2, D9.2 (A), D11.2 (A), D13.2 (A), D15.2 (A), J1.3, J1.4, J2.3, J2.4, J3.3, J3.4, J4.3, J4.4, J5.3, J5.4, J6.3, J6.4, J7.3, J7.4, J8.3, J8.4, J9.9, J9.10, J10.1, R2.2, R7.2, R10.1, R15.2, R18.1, R23.2, R26.1, R31.2, R34.1, RV1.3, RV2.3, RV3.3, RV4.3, TP1.1, TP3.1, TP5.1, TP7.1, U1.2 (GND), U2.12 (GND), U2.15 (~E), U3.2 (GND), U4.2 (GND), U5.6 (TIMER), U5.13 (GND), U6.2 (GND), U7.2 (GND), U8.6 (TIMER), U8.13 (GND), U9.2 (GND), U10.2 (GND), U11.6 (TIMER), U11.13 (GND), U12.2 (GND), U13.2 (GND)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
I_SA1A: U2.5 (I4), U3.1
I_SA1B: U2.4 (I5), U4.1
I_SA2A: U2.3 (I6), U6.1
I_SA2B: U2.2 (I7), U7.1
I_SA3A: U2.23 (I8), U9.1
I_SA3B: U2.22 (I9), U10.1
I_SA4A: U2.21 (I10), U12.1
I_SA4B: U2.20 (I11), U13.1
MUX3OUT: C2.1, J9.5, U2.1 (COM)
unnamed: C6.1, R4.1, R5.1, R6.1, RV1.1, TP1.2, U3.4 (-), U4.4 (-), U5.1 (VIN), U5.3 (~SHDN)
unnamed: C7.1, D9.1 (K), L1.1, U5.12 (SW)
unnamed: C7.2, D10.1 (K), U5.11 (BOOST)
unnamed: C11.1, R12.1, R13.1, R14.1, RV2.1, TP3.2, U6.4 (-), U7.4 (-), U8.1 (VIN), U8.3 (~SHDN)
unnamed: C12.1, D11.1 (K), L2.1, U8.12 (SW)
unnamed: C12.2, D12.1 (K), U8.11 (BOOST)
unnamed: C16.1, R20.1, R21.1, R22.1, RV3.1, TP5.2, U9.4 (-), U10.4 (-), U11.1 (VIN), U11.3 (~SHDN)
unnamed: C17.1, D13.1 (K), L3.1, U11.12 (SW)
unnamed: C17.2, D14.1 (K), U11.11 (BOOST)
unnamed: C21.1, R28.1, R29.1, R30.1, RV4.1, TP7.2, U12.4 (-), U13.4 (-), U14.1 (VIN), U14.3 (~SHDN)
unnamed: C22.1, D15.1 (K), L4.1, U14.12 (SW)
unnamed: C22.2, D16.1 (K), U14.11 (BOOST)
unnamed: D1.2 (A), J1.1, J1.2
unnamed: D2.2 (A), J2.1, J2.2
unnamed: D3.2 (A), J3.1, J3.2
unnamed: D4.2 (A), J4.1, J4.2
unnamed: D5.2 (A), J5.1, J5.2
unnamed: D6.2 (A), J6.1, J6.2
unnamed: D7.2 (A), J7.1, J7.2
unnamed: D8.2 (A), J8.1, J8.2
unnamed: D17.2 (A), L5.2, U15.7 (SW)
unnamed: L1.2, R11.2, U5.10 (SENSE)
unnamed: L2.2, R19.2, U8.10 (SENSE)
unnamed: L3.2, R27.2, U11.10 (SENSE)
unnamed: L4.2, R35.2, U14.10 (SENSE)
unnamed: R8.2, U5.7 (VFB)
unnamed: R8.1, R9.1, R10.2
unnamed: R16.1, R17.1, R18.2
unnamed: R16.2, U8.7 (VFB)
unnamed: R24.1, R25.1, R26.2
unnamed: R24.2, U11.7 (VFB)
unnamed: R32.1, R33.1, R34.2
unnamed: R32.2, U14.7 (VFB)
unnamed: RV1.2, TP2.1, U5.2 (VIN_REG)
unnamed: RV2.2, TP4.1, U8.2 (VIN_REG)
unnamed: RV3.2, TP6.1, U11.2 (VIN_REG)
unnamed: RV4.2, TP8.1, U14.2 (VIN_REG)
S0: J9.2, U2.10 (S0)
S1: J9.4, U2.11 (S1)
S2: J9.3, U2.14 (S2)
S3: J9.1, U2.13 (S3)
TELEM_IBCROUT: U1.1, U2.18 (I13)
TELEM_VBCROUT: R1.2, R2.1, U2.19 (I12)
VDD: C1.1, C3.1, C4.1, C5.1, C9.1, C10.1, C14.1, C15.1, C19.1, C20.1, J9.6, U1.5 (V+), U2.24 (VCC), U3.5 (V+), U4.5 (V+), U6.5 (V+), U7.5 (V+), U9.5 (V+), U10.5 (V+), U12.5 (V+), U13.5 (V+)
V_SA1: R6.2, R7.1, U2.9 (I0)
V_SA2: R14.2, R15.1, U2.8 (I1)
V_SA3: R22.2, R23.1, U2.7 (I2)
V_SA4: R30.2, R31.1, U2.6 (I3)

## KiCad design ECAD/Battery/BatteryMaster.kicad_pcb

Board: 2 copper layers, 90.2 x 95.9 mm, 149 parts (127 on the bottom side), 97 nets.

Parts:
BT1, BT2, BT3, BT4: 18650; 18650-weld
C1, C3, C16: 10uF; C_0805_2012Metric
C2, C4, C5, C6, C9, C10, C11, C12, C13, C14, C15, C17, C18, C19, C20, C21, C22, C23, C24: 0.1uF; C_0805_2012Metric
C7, C8: 20pF; C_0805_2012Metric
F1: 7A; R_1206_3216Metric
H1, H2: Stack Header; PinSocket_2x26_P2.54mm_Vertical
J1: SWD/DEBUG; PinHeader_1x06_P2.54mm_Vertical
JP1: BOOT; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
JP2, JP3: LTDIS; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
MH1, MH2, MH3, MH4: M3; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
Q1, Q4, Q5, Q7, Q8, Q10, Q11, Q12, Q14: DMP3015LSSQ; SOIC-8_3.9x4.9mm_P1.27mm
Q2, Q9, Q13, Q15: Si4186DY; SOIC-8_3.9x4.9mm_P1.27mm
Q3, Q6, Q16, Q19, Q22, Q25: 2N7002; SOT-23
Q17, Q20, Q23, Q26: Si2371EDS-T1-BE3; SOT-23
Q18, Q21, Q24, Q27: DMG6968U-7; SOT-23
R1, R21, R25, R29, R30, R32, R35, R36, R38, R43, R45, R50, R52, R57, R59: 100R; R_0805_2012Metric
R2, R4, R5, R13, R15, R20, R22, R24, R27, R28, R31: 100K; R_0805_2012Metric
R3: 4m; R_1206_3216Metric
R6, R9: 2.49K; R_0805_2012Metric
R7, R8: 162K; R_0805_2012Metric
R10: 40K; R_0805_2012Metric
R11: 30K; R_0805_2012Metric
R12: 7.5K; R_0805_2012Metric
R14: 50K; R_0805_2012Metric
R16, R17, R26, R37, R39, R40, R44, R46, R47, R51, R53, R54, R58, R60, R61: 10K; R_0805_2012Metric
R18: 316K; R_0805_2012Metric
R19: 20K; R_0805_2012Metric
R23: 200K; R_0805_2012Metric
R33: 160R; R_0805_2012Metric
R34: 260R; R_0805_2012Metric
R41, R48, R55, R62: 80R; PinSocket_1x02_P1.27mm_Vertical
R42, R49, R56, R63: 270K; R_0805_2012Metric
SW1, SW2, SW3, SW4, SW5: INHIBIT; Hirose_DF13-02P-1.25DSA_1x02_P1.25mm_Vertical
TH1, TH2, TH3, TH4: 100K NTC; PinSocket_1x02_P1.27mm_Vertical
U1: LM1117-3.3; SOT-223-3_TabPin2
U2: LTC4359-MS8; MSOP-8_3x3mm_P0.65mm
U3: INA181A2; SOT-23-6
U4: MAX6035xxUR30; SOT-23
U5: LM358; SO-8_3.9x4.9mm_P1.27mm
U6: TLV9361IDBVR; SOT-23-5
U7: MAX6369; SOT-23-8
U8: LTC4365TS8-1; TSOT-23-8
U9: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U10: BQ29209; Texas_S-PVSON-N8_ThermalVias
Y1: 8MHz; Crystal_HC49-4H_Vertical

Connections:
+3.3VA: C2.1, R5.2, R6.1, R8.1, U1.2 (VO), U3.6 (V+)
+3V3: C5.1, H2.27, H2.28, Q8.1 (S), Q8.2 (S), Q8.3 (S), Q17.3 (D), Q20.3 (D), Q23.3 (D), Q26.3 (D), R16.1, R17.1, R39.1, R42.1, R46.1, R49.1, R53.1, R56.1, R60.1, R63.1, U7.5 (SET1), U7.6 (SET2), U7.8 (VCC)
+5V: H2.25, H2.26
+BATT: H2.45, H2.46
-BATT: BT2.2 (-), BT4.2 (-), C17.2, C20.2, Q15.5 (D), Q15.6 (D), Q15.7 (D), Q15.8 (D), U10.5 (GND), U10.6 (~CB_EN), U10.9 (PGND)
/BOOT0: R15.1, U9.44 (BOOT0)
/BOOT1: R13.1, U9.20 (PB2)
/D+: J1.6, U9.33 (PA12)
/D-: J1.5, U9.32 (PA11)
/H1CTRL: R36.2, R38.2, U9.45 (PB8)
/H2CTRL: R43.2, R45.2, U9.46 (PB9)
/H3CTRL: R50.2, R52.2, U9.21 (PB10)
/H4CTRL: R57.2, R59.2, U9.22 (PB11)
/HANDSHAKE: R14.1, U7.1 (WDI), U9.18 (PB0)
/RESET: R26.2, U9.7 (NRST)
/SCL: H1.43, U9.42 (PB6)
/SDA: H1.41, U9.43 (PB7)
/SWDCLK: J1.3, U9.37 (PA14)
/SWDIO: J1.2, U9.34 (PA13)
/TBAT1: C21.1, R42.2, TH1.1, U9.10 (PA0)
/TBAT2: C22.1, R49.2, TH2.1, U9.11 (PA1)
/TBAT3: C23.1, R56.2, TH3.1, U9.12 (PA2)
/TBAT4: C24.1, R63.2, TH4.1, U9.13 (PA3)
/TELEM_IBAT: U3.1, U5.3 (+), U5.6 (-), U9.14 (PA4)
/TELEM_VBAT: C9.1, R23.2, R24.1, U9.15 (PA5)
BCR_OUT: H2.41, H2.42, H2.43, H2.44, Q1.1 (S), Q1.2 (S), Q1.3 (S), R1.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C16.2, C21.2, C22.2, C23.2, C24.2, H2.21, H2.22, H2.29, H2.30, H2.31, H2.32, J1.4, JP1.1 (A), MH1.1, MH2.1, MH3.1, MH4.1, Q3.2 (S), Q6.2 (S), Q13.5 (D), Q13.6 (D), Q13.7 (D), Q13.8 (D), Q16.2 (S), Q18.2 (S), Q19.2 (S), Q21.2 (S), Q22.2 (S), Q24.2 (S), Q25.2 (S), Q27.2 (S), R2.2, R4.2, R7.2, R9.2, R12.2, R13.2, R14.2, R19.2, R22.2, R24.2, R27.2, R37.2, R40.2, R44.2, R47.2, R51.2, R54.2, R58.2, R61.2, TH1.2, TH2.2, TH3.2, TH4.2, U1.1 (GND), U2.6 (Vss), U3.2 (GND), U4.3 (GND), U5.4 (V-), U6.2 (V-), U7.2 (GND), U7.4 (SET0), U8.4 (GND), U9.8 (VSSA), U9.23 (VSS), U9.35 (VSS), U9.47 (VSS)
unnamed: BT1.1 (+), BT3.1 (+), F1.1, R32.1, R33.1
unnamed: BT1.2 (-), BT2.1 (+), BT3.2 (-), BT4.1 (+), R34.1, R35.1
unnamed: C1.1, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q2.1 (S), Q2.2 (S), Q2.3 (S), R3.2, U1.3 (VI), U2.2 (SRC), U2.4 (IN), U2.5 (~SHDN), U3.3 (+)
unnamed: C3.1, C4.1, Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q4.1 (S), Q4.2 (S), Q4.3 (S), R10.1, U2.8 (OUT), U4.1 (IN), U6.5 (V+)
unnamed: C6.1, Q5.1 (S), Q5.2 (S), Q5.3 (S), Q7.1 (S), Q7.2 (S), Q7.3 (S), U5.8 (V+)
unnamed: C7.1, U9.5 (PD0), Y1.1
unnamed: C8.1, U9.6 (PD1), Y1.2
unnamed: C12.1, Q12.1 (S), Q12.2 (S), Q12.3 (S), Q14.1 (S), Q14.2 (S), Q14.3 (S), R30.1, R31.1
unnamed: C12.2, JP2.1, Q12.4 (G), Q14.4 (G), SW4.2 (B)
unnamed: C15.1, JP3.2, Q13.4 (G), Q15.4 (G), SW5.1 (A)
unnamed: C15.2, Q13.1 (S), Q13.2 (S), Q13.3 (S), Q15.1 (S), Q15.2 (S), Q15.3 (S), R28.2, R29.2
unnamed: C17.1, R32.2, U10.7 (VDD)
unnamed: C18.1, R33.2, U10.1 (VC2)
unnamed: C18.2, C19.1, R34.2, U10.2 (VC1)
unnamed: C19.2, R35.2, U10.3 (VC1_CB)
unnamed: C20.1, U10.4 (CD)
unnamed: F1.2, Q14.5 (D), Q14.6 (D), Q14.7 (D), Q14.8 (D)
unnamed: JP1.2 (C), R15.2
unnamed: JP2.2, R28.1
unnamed: JP3.1, R31.2
unnamed: Q1.4 (G), R2.1, SW1.2 (B)
unnamed: Q2.4 (G), U2.1 (GATE)
unnamed: Q3.1 (G), Q4.4 (G), U6.1
unnamed: Q3.3 (D), R11.2, R12.1
unnamed: Q5.4 (G), U5.7
unnamed: Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), R3.1, U3.4 (-)
unnamed: Q6.1 (G), R16.2, U7.7 (~WDO)
unnamed: Q6.3 (D), Q8.4 (G), R17.2
unnamed: Q7.4 (G), U5.1
unnamed: Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), R18.1, R20.1, U8.1 (Vin)
unnamed: Q9.4 (G), U8.8 (GATE)
unnamed: Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q10.1 (S), Q10.2 (S), Q10.3 (S), R21.1
unnamed: Q10.4 (G), R22.1, SW2.2 (B)
unnamed: Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), Q11.1 (S), Q11.2 (S), Q11.3 (S), R25.1
unnamed: Q11.4 (G), R27.1, SW3.2 (B)
unnamed: Q9.1 (S), Q9.2 (S), Q9.3 (S), Q12.5 (D), Q12.6 (D), Q12.7 (D), Q12.8 (D), R23.1, U8.7 (Vout)
unnamed: Q16.1 (G), R36.1, R37.1
unnamed: Q16.3 (D), Q17.1 (G), R39.2
unnamed: Q17.2 (S), R41.1
unnamed: Q18.1 (G), R38.1, R40.1
unnamed: Q18.3 (D), R41.2
unnamed: Q19.1 (G), R43.1, R44.1
unnamed: Q19.3 (D), Q20.1 (G), R46.2
unnamed: Q20.2 (S), R48.1
unnamed: Q21.1 (G), R45.1, R47.1
unnamed: Q21.3 (D), R48.2
unnamed: Q22.1 (G), R50.1, R51.1
unnamed: Q22.3 (D), Q23.1 (G), R53.2
unnamed: Q23.2 (S), R55.1
unnamed: Q24.1 (G), R52.1, R54.1
unnamed: Q24.3 (D), R55.2
unnamed: Q25.1 (G), R57.1, R58.1
unnamed: Q25.3 (D), Q26.1 (G), R60.2
unnamed: Q26.2 (S), R62.1
unnamed: Q27.1 (G), R59.1, R61.1
unnamed: Q27.3 (D), R62.2
unnamed: R1.2, SW1.1 (A)
unnamed: R4.1, R5.1, U3.5 (REF)
unnamed: R6.2, R7.1, U5.2 (-)
unnamed: R8.2, R9.1, U5.5 (+)
unnamed: R10.2, R11.1, U6.4 (-)
unnamed: R18.2, R19.1, U8.3 (OV)
unnamed: R20.2, U8.2 (UV), U8.5 (~SHDN)
unnamed: R21.2, SW2.1 (A)
unnamed: R25.2, SW3.1 (A)
unnamed: R29.1, SW5.2 (B)
unnamed: R30.2, SW4.1 (A)
unnamed: U4.2 (OUT), U6.3 (+)
PCM_IN: H2.35, H2.36, Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D)
VDD: C10.1, C11.1, C13.1, C14.1, C16.1, J1.1, JP1.3 (B), Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), R26.1, U9.1 (VBAT), U9.9 (VDDA), U9.24 (VDD), U9.36 (VDD), U9.48 (VDD)

## KiCad design ECAD/EPS/TJ-EPS.kicad_pcb

Board: 4 copper layers, 90.2 x 95.9 mm, 228 parts (99 on the bottom side), 157 nets.

Parts:
C1, C3, C4, C8, C9, C10, C11, C13, C14, C15, C16, C21, C23, C24, C25, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42: 0.1uF; C_0805_2012Metric
C2, C5: 0.01uF; C_0805_2012Metric
C6, C7: 20pF; C_0805_2012Metric
C12, C17, C20, C22, C27: 10uF; C_0805_2012Metric
C18, C19, C28, C29: 22uF; C_1210_3225Metric
C26: 1uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: RR264MM; D_SOD-123F
H1: Stack Header 2; PinSocket_2x26_P2.54mm_Vertical
H2: Stack Header 1; PinSocket_2x26_P2.54mm_Vertical
J1: SWD/DEBUG; PinHeader_1x06_P2.54mm_Vertical
J2: Solar Daughterboard Connector; PinHeader_2x06_P2.54mm_Vertical
JP1: BOOT; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11: JP; SolderJumper-4_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 4.7uH; L_Abracon_ASPI-0630LR
L2: 3.3uH; L_Abracon_ASPI-0630LR
MH1, MH2, MH3, MH4: M2.5; MountingHole_2.7mm_M2.5
MH5, MH6, MH7, MH8: M3; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
Q1, Q3, Q5, Q6, Q7, Q10, Q11, Q12, Q14, Q16, Q18, Q20, Q22, Q24, Q26, Q28, Q30: 2N7002; SOT-23
Q2, Q4, Q8, Q9, Q13, Q15, Q17, Q19, Q21, Q23, Q25, Q27, Q29, Q31: IRF7458; SOIC-8_3.9x4.9mm_P1.27mm
R1: 270K; R_0805_2012Metric
R2: 50K; R_0805_2012Metric
R3, R6, R19, R34, R35, R36, R37, R42, R48, R54, R60, R66, R72, R78, R84, R90, R96: 100K; R_0805_2012Metric
R4, R5, R9, R12, R13, R14, R22, R23, R24, R25, R26, R27, R39, R40, R45, R46, R51, R52, R57, R58, R63, R64, R69, R70, R75, R76, R81, R82, R87, R88, R93, R94: 10K; R_0805_2012Metric
R7, R8: 2.2K; R_0805_2012Metric
R10: 124K; R_0805_2012Metric
R11, R21: 22.1K; R_0805_2012Metric
R15, R28, R29: 10m; R_1206_3216Metric
R16: 9.5K; R_0805_2012Metric
R17: 3K; R_0805_2012Metric
R18, R41, R47, R53, R59, R65, R71, R77, R83, R89, R95: 200K; R_0805_2012Metric
R20: 73.2K; R_0805_2012Metric
R30, R32: 6K; R_0805_2012Metric
R31, R33: 4K; R_0805_2012Metric
R38, R44, R50, R56, R62, R68, R74, R80, R86, R92: 100R; R_0805_2012Metric
R43, R49, R55, R61, R67, R73, R79, R85, R91, R97: 4m; R_1206_3216Metric
TH1: 100K NTC; R_1206_3216Metric
U1, U2: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm
U3: MAX6369; SOT-23-8
U4: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U5: LM1117-3.3; SOT-223-3_TabPin2
U6: TPS54394RSAR; Texas_S-PVQFN-N16_EP2.7x2.7mm_ThermalVias
U7, U10, U11: MAX4373F; SO-8_3.9x4.9mm_P1.27mm
U8, U9: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm
U12, U13, U14, U15, U16, U17, U18, U19, U20, U21: INA180A3; SOT-23-5
Y1: 8MHz; Crystal_HC49-4H_Vertical

Connections:
+3.3VA: C4.1, C28.1, C29.1, L2.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q9.1 (S), Q9.2 (S), Q9.3 (S), R4.1, R5.1, R20.1, R23.1, U3.5 (SET1), U3.6 (SET2), U3.8 (VCC)
+3V3: H2.27, H2.28, JP2.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), JP6.1 (A), JP7.1 (A), JP8.1 (A), JP9.1 (A), JP10.1 (A), JP11.1 (A), R1.1, R29.1, R36.1, U11.7 (RS-)
+5V: H2.25, H2.26, JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), JP6.3 (B), JP7.3 (B), JP8.3 (B), JP9.3 (B), JP10.3 (B), JP11.3 (B), R28.1, R34.1, U10.7 (RS-)
+BATT: H2.45, H2.46, JP2.4 (D), JP3.4 (D), JP4.4 (D), JP5.4 (D), JP6.4 (D), JP7.4 (D), JP8.4 (D), JP9.4 (D), JP10.4 (D), JP11.4 (D), R15.1, R18.1, U7.7 (RS-)
/BOOT0: R6.1, U4.44 (BOOT0)
/BOOT1: R3.1, U4.20 (PB2)
/D+: J1.6, U4.33 (PA12)
/D-: J1.5, U4.32 (PA11)
/HANDSHAKE: R2.1, U3.1 (WDI), U4.25 (PB12)
/RESET: R9.2, U4.7 (NRST)
/SCL: H1.43, R8.2, U4.42 (PB6)
/SDA: H1.41, R7.2, U4.43 (PB7)
/SWDCLK: J1.3, U4.37 (PA14)
/SWDIO: J1.2, U4.34 (PA13)
BCR_OUT: H2.41, H2.42, H2.43, H2.44, J2.7, J2.8
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C22.2, C23.2, C24.2, C26.1, C27.1, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), H2.21, H2.22, H2.29, H2.30, H2.31, H2.32, J1.4, J2.11, J2.12, JP1.1 (A), Q1.2 (S), Q3.2 (S), Q6.2 (S), Q7.2 (S), Q12.2 (S), Q14.2 (S), Q16.2 (S), Q18.2 (S), Q20.2 (S), Q22.2 (S), Q24.2 (S), Q26.2 (S), Q28.2 (S), Q30.2 (S), R2.2, R3.2, R11.2, R17.2, R19.2, R21.2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
MUX1OUT: C2.1, U1.1 (COM), U4.10 (PA0)
MUX2OUT: C5.1, U2.1 (COM), U4.11 (PA1)
MUX3OUT: J2.5, U4.12 (PA2)
MUX4OUT: J2.6, U4.13 (PA3)
unnamed: C6.1, U4.5 (PD0), Y1.1
unnamed: C7.1, U4.6 (PD1), Y1.2
unnamed: C13.1, MH5.1
unnamed: C14.1, MH6.1
unnamed: C15.1, MH7.1
unnamed: C16.1, MH8.1
unnamed: C18.1, C19.1, L1.1, Q8.1 (S), Q8.2 (S), Q8.3 (S), R10.1, R22.1
unnamed: C21.1, U6.4 (VBST1)
unnamed: C21.2, L1.2, U6.5 (SW1)
unnamed: C25.1, U6.1 (VBST2)
unnamed: C25.2, L2.1, U6.16 (SW2)
unnamed: C26.2, U6.11 (VREG5)
unnamed: JP1.2 (C), R6.2
unnamed: JP2.2 (C), Q13.1 (S), Q13.2 (S), Q13.3 (S), R40.1
unnamed: JP3.2 (C), Q15.1 (S), Q15.2 (S), Q15.3 (S), R46.1
unnamed: JP4.2 (C), Q17.1 (S), Q17.2 (S), Q17.3 (S), R52.1
unnamed: JP5.2 (C), Q19.1 (S), Q19.2 (S), Q19.3 (S), R58.1
unnamed: JP6.2 (C), Q21.1 (S), Q21.2 (S), Q21.3 (S), R64.1
unnamed: JP7.2 (C), Q23.1 (S), Q23.2 (S), Q23.3 (S), R70.1
unnamed: JP8.2 (C), Q25.1 (S), Q25.2 (S), Q25.3 (S), R76.1
unnamed: JP9.2 (C), Q27.1 (S), Q27.2 (S), Q27.3 (S), R82.1
unnamed: JP10.2 (C), Q29.1 (S), Q29.2 (S), Q29.3 (S), R88.1
unnamed: JP11.2 (C), Q31.1 (S), Q31.2 (S), Q31.3 (S), R94.1
unnamed: Q1.1 (G), R4.2, U3.7 (~WDO)
unnamed: Q1.3 (D), Q2.4 (G), R5.2
unnamed: Q3.3 (D), Q5.2 (S)
unnamed: Q4.4 (G), Q5.3 (D), R12.2
unnamed: Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), R15.2, U7.8 (RS+)
unnamed: Q5.1 (G), R13.2, U7.6 (COUT1)
unnamed: Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), R28.2, U10.8 (RS+)
unnamed: Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), R29.2, U11.8 (RS+)
unnamed: Q10.1 (G), R24.2, U10.6 (COUT1)
unnamed: Q6.3 (D), Q10.2 (S)
unnamed: Q8.4 (G), Q10.3 (D), R22.2
unnamed: Q11.1 (G), R25.2, U11.6 (COUT1)
unnamed: Q7.3 (D), Q11.2 (S)
unnamed: Q9.4 (G), Q11.3 (D), R23.2
unnamed: Q12.1 (G), R38.1, R39.1
unnamed: Q12.3 (D), Q13.4 (G), R40.2
unnamed: Q13.5 (D), Q13.6 (D), Q13.7 (D), Q13.8 (D), R41.1, R43.2, U12.3 (+)
unnamed: Q14.1 (G), R44.1, R45.1
unnamed: Q14.3 (D), Q15.4 (G), R46.2
unnamed: Q15.5 (D), Q15.6 (D), Q15.7 (D), Q15.8 (D), R47.1, R49.2, U13.3 (+)
unnamed: Q16.1 (G), R50.1, R51.1
unnamed: Q16.3 (D), Q17.4 (G), R52.2
unnamed: Q17.5 (D), Q17.6 (D), Q17.7 (D), Q17.8 (D), R53.1, R55.2, U14.3 (+)
unnamed: Q18.1 (G), R56.1, R57.1
unnamed: Q18.3 (D), Q19.4 (G), R58.2
unnamed: Q19.5 (D), Q19.6 (D), Q19.7 (D), Q19.8 (D), R59.1, R61.2, U15.3 (+)
unnamed: Q20.1 (G), R62.1, R63.1
unnamed: Q20.3 (D), Q21.4 (G), R64.2
unnamed: Q21.5 (D), Q21.6 (D), Q21.7 (D), Q21.8 (D), R65.1, R67.2, U16.3 (+)
unnamed: Q22.1 (G), R68.1, R69.1
unnamed: Q22.3 (D), Q23.4 (G), R70.2
unnamed: Q23.5 (D), Q23.6 (D), Q23.7 (D), Q23.8 (D), R71.1, R73.2, U17.3 (+)
unnamed: Q24.1 (G), R74.1, R75.1
unnamed: Q24.3 (D), Q25.4 (G), R76.2
unnamed: Q25.5 (D), Q25.6 (D), Q25.7 (D), Q25.8 (D), R77.1, R79.2, U18.3 (+)
unnamed: Q26.1 (G), R80.1, R81.1
unnamed: Q26.3 (D), Q27.4 (G), R82.2
unnamed: Q27.5 (D), Q27.6 (D), Q27.7 (D), Q27.8 (D), R83.1, R85.2, U19.3 (+)
unnamed: Q28.1 (G), R86.1, R87.1
unnamed: Q28.3 (D), Q29.4 (G), R88.2
unnamed: Q29.5 (D), Q29.6 (D), Q29.7 (D), Q29.8 (D), R89.1, R91.2, U20.3 (+)
unnamed: Q30.1 (G), R92.1, R93.1
unnamed: Q30.3 (D), Q31.4 (G), R94.2
unnamed: Q31.5 (D), Q31.6 (D), Q31.7 (D), Q31.8 (D), R95.1, R97.2, U21.3 (+)
unnamed: R10.2, R11.1, U6.9 (VFB1)
unnamed: R16.2, R17.1, U7.3 (CIN1)
unnamed: R20.2, R21.1, U6.12 (VFB2)
unnamed: R30.2, R31.1, U10.3 (CIN1)
unnamed: R32.2, R33.1, U11.3 (CIN1)
unnamed: U8.9 (QH'), U9.14 (SER)
PCM_IN: C17.1, C20.2, C27.2, H2.35, H2.36, Q4.1 (S), Q4.2 (S), Q4.3 (S), R12.1, U5.3 (VI), U6.2 (VIN2), U6.3 (VIN1), U6.7 (EN1), U6.14 (EN2)
RST3V3: Q7.1 (G), U4.17 (PA7)
RST3V3OCP: R27.2, U4.28 (PB15), U11.5 (~RESET)
RST5V: Q6.1 (G), U4.29 (PA8)
RST5VOCP: R26.2, U4.27 (PB14), U10.5 (~RESET)
RSTBATV: Q3.1 (G), U4.30 (PA9)
RSTBATVOCP: R14.2, U4.26 (PB13), U7.5 (~RESET)
S0: J2.2, U1.10 (S0), U2.10 (S0), U4.45 (PB8)
S1: J2.4, U1.11 (S1), U2.11 (S1), U4.46 (PB9)
S2: J2.3, U1.14 (S2), U2.14 (S2), U4.21 (PB10)
S3: J2.1, U1.13 (S3), U2.13 (S3), U4.22 (PB11)
SRCLK: U4.14 (PA4), U8.11 (SRCLK), U9.11 (SRCLK)
SRLCH: U4.15 (PA5), U8.12 (RCLK), U9.12 (RCLK)
SRSERIN: U4.16 (PA6), U8.14 (SER)
SW1: D7.1 (K), H2.9, R79.1, U18.4 (-)
SW1GATE: R74.2, U8.15 (QA)
SW2: D1.1 (K), H2.10, R43.1, U12.4 (-)
SW2GATE: R38.2, U8.1 (QB)
SW3: D2.1 (K), H2.11, R49.1, U13.4 (-)
SW3GATE: R44.2, U8.2 (QC)
SW4: D4.1 (K), H2.12, R61.1, U15.4 (-)
SW4GATE: R56.2, U8.3 (QD)
SW5: D8.1 (K), H2.13, R85.1, U19.4 (-)
SW5GATE: R80.2, U8.4 (QE)
SW6: D10.1 (K), H2.14, R97.1, U21.4 (-)
SW6GATE: R92.2, U8.5 (QF)
SW7: D5.1 (K), H2.15, R67.1, U16.4 (-)
SW7GATE: R62.2, U8.6 (QG)
SW8: D3.1 (K), H2.16, R55.1, U14.4 (-)
SW8GATE: R50.2, U8.7 (QH)
SW9: D9.1 (K), H2.17, R91.1, U20.4 (-)
SW9GATE: R86.2, U9.15 (QA)
SW10: D6.1 (K), H2.18, R73.1, U17.4 (-)
SW10GATE: R68.2, U9.1 (QB)
TELEM_I3V3: R32.1, U2.19 (I12), U11.2 (OUT)
TELEM_I5V: R30.1, U2.20 (I11), U10.2 (OUT)
TELEM_IBATV: R16.1, U2.21 (I10), U7.2 (OUT)
TELEM_ISW1: U2.9 (I0), U18.1
TELEM_ISW2: U2.8 (I1), U12.1
TELEM_ISW3: U2.7 (I2), U13.1
TELEM_ISW4: U2.6 (I3), U15.1
TELEM_ISW5: U2.5 (I4), U19.1
TELEM_ISW6: U2.4 (I5), U21.1
TELEM_ISW7: U2.3 (I6), U16.1
TELEM_ISW8: U2.2 (I7), U14.1
TELEM_ISW9: U2.23 (I8), U20.1
TELEM_ISW10: U2.22 (I9), U17.1
TELEM_TBRD: R1.2, TH1.1, U1.18 (I13)
TELEM_V3V3: R36.2, R37.1, U1.19 (I12)
TELEM_V5V: R34.2, R35.1, U1.20 (I11)
TELEM_VBATV: R18.2, R19.1, U1.21 (I10)
TELEM_VSW1: R77.2, R78.1, U1.9 (I0)
TELEM_VSW2: R41.2, R42.1, U1.8 (I1)
TELEM_VSW3: R47.2, R48.1, U1.7 (I2)
TELEM_VSW4: R59.2, R60.1, U1.6 (I3)
TELEM_VSW5: R83.2, R84.1, U1.5 (I4)
TELEM_VSW6: R95.2, R96.1, U1.4 (I5)
TELEM_VSW7: R65.2, R66.1, U1.3 (I6)
TELEM_VSW8: R53.2, R54.1, U1.2 (I7)
TELEM_VSW9: R89.2, R90.1, U1.23 (I8)
TELEM_VSW10: R71.2, R72.1, U1.22 (I9)
VCC: C22.1, C23.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, R13.1, R14.1, R24.1, R25.1, R26.1, R27.1, U5.2 (VO), U7.1 (Vcc), U10.1 (Vcc), U11.1 (Vcc), U12.5 (V+), U13.5 (V+), U14.5 (V+), U15.5 (V+), U16.5 (V+), U17.5 (V+), U18.5 (V+), U19.5 (V+), U20.5 (V+), U21.5 (V+)
VDD: C1.1, C3.1, C8.1, C9.1, C10.1, C11.1, C12.1, C24.1, C30.1, J1.1, JP1.3 (B), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), R7.1, R8.1, R9.1, U1.24 (VCC), U2.24 (VCC), U4.1 (VBAT), U4.9 (VDDA), U4.24 (VDD), U4.36 (VDD), U4.48 (VDD), U8.10 (~SRCLR), U8.16 (VCC), U9.10 (~SRCLR), U9.16 (VCC)
VUSB: H1.32, J2.9, J2.10
