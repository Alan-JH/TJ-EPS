File: ECAD/SolarConditioning.sch (KiCad schematic (older format))
At the start: 47 parts

Commit message: implement a retry timer
Parts:
- D? (x8): value 1N4148 -> 1N4004
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 11 32
+Sheet 11 35
 Title "TJ Custom EPS"
 Date ""
@@
 P 1750 4500
 F 0 "D?" V 1800 4550 50  0000 L CNN
-F 1 "1N4148" V 1700 4550 50  0000 L CNN
+F 1 "1N4004" V 1700 4550 50  0000 L CNN
 F 2 "" H 1750 4500 50  0001 C CNN
 F 3 "~" H 1750 4500 50  0001 C CNN
@@
 P 1750 4050
 F 0 "D?" V 1800 4000 50  0000 R CNN
-F 1 "1N4148" V 1700 4000 50  0000 R CNN
+F 1 "1N4004" V 1700 4000 50  0000 R CNN
 F 2 "" H 1750 4050 50  0001 C CNN
 F 3 "~" H 1750 4050 50  0001 C CNN
@@
 P 1750 2900
 F 0 "D?" V 1800 2950 50  0000 L CNN
-F 1 "1N4148" V 1700 2950 50  0000 L CNN
+F 1 "1N4004" V 1700 2950 50  0000 L CNN
 F 2 "" H 1750 2900 50  0001 C CNN
 F 3 "~" H 1750 2900 50  0001 C CNN
@@
 P 1750 2450
 F 0 "D?" V 1800 2400 50  0000 R CNN
-F 1 "1N4148" V 1700 2400 50  0000 R CNN
+F 1 "1N4004" V 1700 2400 50  0000 R CNN
 F 2 "" H 1750 2450 50  0001 C CNN
 F 3 "~" H 1750 2450 50  0001 C CNN
@@
 P 1750 1300
 F 0 "D?" V 1800 1350 50  0000 L CNN
-F 1 "1N4148" V 1700 1350 50  0000 L CNN
+F 1 "1N4004" V 1700 1350 50  0000 L CNN
 F 2 "" H 1750 1300 50  0001 C CNN
 F 3 "~" H 1750 1300 50  0001 C CNN
@@
 P 1750 850
 F 0 "D?" V 1800 800 50  0000 R CNN
-F 1 "1N4148" V 1700 800 50  0000 R CNN
+F 1 "1N4004" V 1700 800 50  0000 R CNN
 F 2 "" H 1750 850 50  0001 C CNN
 F 3 "~" H 1750 850 50  0001 C CNN
@@
 P 1750 6100
 F 0 "D?" V 1800 6150 50  0000 L CNN
-F 1 "1N4148" V 1700 6150 50  0000 L CNN
+F 1 "1N4004" V 1700 6150 50  0000 L CNN
 F 2 "" H 1750 6100 50  0001 C CNN
 F 3 "~" H 1750 6100 50  0001 C CNN
@@
 P 1750 5650
 F 0 "D?" V 1800 5600 50  0000 R CNN
-F 1 "1N4148" V 1700 5600 50  0000 R CNN
+F 1 "1N4004" V 1700 5600 50  0000 R CNN
 F 2 "" H 1750 5650 50  0001 C CNN
 F 3 "~" H 1750 5650 50  0001 C CNN

Commit message: add solar telemetry sheet
Parts:
- removed J?: S1A, symbol Connector:Conn_01x05_Female
- removed J?: S1B, symbol Connector:Conn_01x05_Female
- removed J?: S2A, symbol Connector:Conn_01x05_Female
- removed J?: S2B, symbol Connector:Conn_01x05_Female
- removed J?: S3A, symbol Connector:Conn_01x05_Female
- removed J?: S3B, symbol Connector:Conn_01x05_Female
- removed J?: S4B, symbol Connector:Conn_01x05_Female
- removed J?: S4A, symbol Connector:Conn_01x05_Female
- added J?: S1A, symbol Connector:Conn_01x04_Female
- added J?: S1B, symbol Connector:Conn_01x04_Female
- added J?: S2A, symbol Connector:Conn_01x04_Female
- added J?: S2B, symbol Connector:Conn_01x04_Female
- added J?: S3A, symbol Connector:Conn_01x04_Female
- added J?: S3B, symbol Connector:Conn_01x04_Female
- added J?: S4A, symbol Connector:Conn_01x04_Female
- added J?: S4B, symbol Connector:Conn_01x04_Female
Connections:
- wire segments 178 -> 182
Other:
- moved on the sheet: D?, Q?, U?

Commit message: Implement solar telemetry, add a sheet layout
Parts:
- added H? (x4): M2.5, symbol Mechanical:MountingHole_Pad
- added J?: TELEM_IN, symbol Connector:Conn_01x07_Male
Connections:
- net +3.3VA: now also J?.1 (Pin_1)
- net GND: now also H?.1, H?.1, H?.1, H?.1, J?.7 (Pin_7)
- new net SOLAR_CS0: J?.5 (Pin_5)
- new net SOLAR_CS1: J?.6 (Pin_6)
- new net SOLAR_MISO: J?.3 (Pin_3)
- new net SOLAR_MOSI: J?.4 (Pin_4)
- new net SOLAR_SCK: J?.2 (Pin_2)
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 11 36
+Sheet 11 44
 Title "TJ Custom EPS"
 Date ""
@@
 	2150 5750 2150 6400
 $Sheet
-S 8150 1100 2450 1100
+S 9400 1200 1000 500
 U 636144E9
 F0 "SolarTelem" 50
 F1 "SolarTelem.sch" 50
 $EndSheet
+$Comp
+L Mechanical:MountingHole_Pad H?
+U 1 1 61DE3A90
+P 10400 2900
+AR Path="/61BEC565/636144E9/61DE3A90" Ref="H?"  Part="1"
+AR Path="/61BEC565/61DE3A90" Ref="H?"  Part="1"
+F 0 "H?" H 10500 2949 50  0000 L CNN
+F 1 "M2.5" H 10500 2858 50  0000 L CNN
+F 2 "" H 10400 2900 50  0001 C CNN
+F 3 "~" H 10400 2900 50  0001 C CNN
+	1    10400 2900
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR?
+U 1 1 61DE3A96
+P 10400 3000
+AR Path="/61BEC565/636144E9/61D77E3B/61DE3A96" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD2717/61DE3A96" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B22/61DE3A96" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B28/61DE3A96" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4551/61DE3A96" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4557/61DE3A96" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD520E/61DE3A96" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD5214/61DE3A96" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/61DE3A96" Ref="#PWR?"  Part="1"
+F 0 "#PWR?" H 10400 2750 50  0001 C CNN
+F 1 "GND" H 10405 2827 50  0000 C CNN
+F 2 "" H 10400 3000 50  0001 C CNN
+F 3 "" H 10400 3000 50  0001 C CNN
+	1    10400 3000
+	1    0    0    -1
+$EndComp
+$Comp
+L Mechanical:MountingHole_Pad H?
+U 1 1 61DE3A9C
+P 10800 2900
+AR Path="/61BEC565/636144E9/61DE3A9C" Ref="H?"  Part="1"
+AR Path="/61BEC565/61DE3A9C" Ref="H?"  Part="1"
+F 0 "H?" H 10900 2949 50  0000 L CNN
+F 1 "M2.5" H 10900 2858 50  0000 L CNN
+F 2 "" H 10800 2900 50  0001 C CNN
+F 3 "~" H 10800 2900 50  0001 C CNN
+	1    10800 2900
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR?
+U 1 1 61DE3AA2
+P 10800 3000
+AR Path="/61BEC565/636144E9/61D77E3B/61DE3AA2" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD2717/61DE3AA2" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B22/61DE3AA2" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B28/61DE3AA2" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4551/61DE3AA2" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4557/61DE3AA2" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD520E/61DE3AA2" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD5214/61DE3AA2" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/61DE3AA2" Ref="#PWR?"  Part="1"
+F 0 "#PWR?" H 10800 2750 50  0001 C CNN
+F 1 "GND" H 10805 2827 50  0000 C CNN
+F 2 "" H 10800 3000 50  0001 C CNN
+F 3 "" H 10800 3000 50  0001 C CNN
+	1    10800 3000
+	1    0    0    -1
+$EndComp
+$Comp
+L Mechanical:MountingHole_Pad H?
+U 1 1 61DE3AA8
+P 10400 3450
+AR Path="/61BEC565/636144E9/61DE3AA8" Ref="H?"  Part="1"
+AR Path="/61BEC565/61DE3AA8" Ref="H?"  Part="1"
+F 0 "H?" H 10500 3499 50  0000 L CNN
+F 1 "M2.5" H 10500 3408 50  0000 L CNN
+F 2 "" H 10400 3450 50  0001 C CNN
+F 3 "~" H 10400 3450 50  0001 C CNN
+	1    10400 3450
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR?
+U 1 1 61DE3AAE
+P 10400 3550
+AR Path="/61BEC565/636144E9/61D77E3B/61DE3AAE" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD2717/61DE3AAE" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B22/61DE3AAE" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B28/61DE3AAE" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4551/61DE3AAE" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4557/61DE3AAE" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD520E/61DE3AAE" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD5214/61DE3AAE" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/61DE3AAE" Ref="#PWR?"  Part="1"
+F 0 "#PWR?" H 10400 3300 50  0001 C CNN
+F 1 "GND" H 10405 3377 50  0000 C CNN
+F 2 "" H 10400 3550 50  0001 C CNN
+F 3 "" H 10400 3550 50  0001 C CNN
+	1    10400 3550
+	1    0    0    -1
+$EndComp
+$Comp
+L Mechanical:MountingHole_Pad H?
+U 1 1 61DE3AB4
+P 10800 3450
+AR Path="/61BEC565/636144E9/61DE3AB4" Ref="H?"  Part="1"
+AR Path="/61BEC565/61DE3AB4" Ref="H?"  Part="1"
+F 0 "H?" H 10900 3499 50  0000 L CNN
+F 1 "M2.5" H 10900 3408 50  0000 L CNN
+F 2 "" H 10800 3450 50  0001 C CNN
+F 3 "~" H 10800 3450 50  0001 C CNN
+	1    10800 3450
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR?
+U 1 1 61DE3ABA
+P 10800 3550
+AR Path="/61BEC565/636144E9/61D77E3B/61DE3ABA" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD2717/61DE3ABA" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B22/61DE3ABA" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B28/61DE3ABA" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4551/61DE3ABA" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4557/61DE3ABA" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD520E/61DE3ABA" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD5214/61DE3ABA" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/61DE3ABA" Ref="#PWR?"  Part="1"
+F 0 "#PWR?" H 10800 3300 50  0001 C CNN
+F 1 "GND" H 10805 3377 50  0000 C CNN
+F 2 "" H 10800 3550 50  0001 C CNN
+F 3 "" H 10800 3550 50  0001 C CNN
+	1    10800 3550
+	1    0    0    -1
+$EndComp
+$Comp
+L power:+3.3VA #PWR?
+U 1 1 61EA4355
+P 8950 1150
+F 0 "#PWR?" H 8950 1000 50  0001 C CNN
+F 1 "+3.3VA" H 8965 1323 50  0000 C CNN
+F 2 "" H 8950 1150 50  0001 C CNN
+F 3 "" H 8950 1150 50  0001 C CNN
+	1    8950 1150
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR?
+U 1 1 61EA435C
+P 8850 1750
+AR Path="/61BEC565/636144E9/61D77E3B/61EA435C" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD2717/61EA435C" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B22/61EA435C" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD3B28/61EA435C" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4551/61EA435C" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD4557/61EA435C" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD520E/61EA435C" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61DD5214/61EA435C" Ref="#PWR?"  Part="1"
+AR Path="/61BEC565/636144E9/61EA435C" Ref="#PWR?"  Part="1"
+F 0 "#PWR?" H 8850 1500 50  0001 C CNN
+F 1 "GND" H 8855 1577 50  0000 C CNN
+F 2 "" H 8850 1750 50  0001 C CNN
+F 3 "" H 8850 1750 50  0001 C CNN
+	1    8850 1750
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	8750 1750 8850 1750
+$Comp
+L Connector:Conn_01x07_Male J?
+U 1 1 61EBD280
+P 8550 1450
+F 0 "J?" H 8658 1931 50  0000 C CNN
+F 1 "TELEM_IN" H 8658 1840 50  0000 C CNN
+F 2 "" H 8550 1450 50  0001 C CNN
+F 3 "~" H 8550 1450 50  0001 C CNN
+	1    8550 1450
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	8750 1150 8950 1150
+Text GLabel 8750 1250 2    50   Input ~ 0
+SOLAR_SCK
+Text GLabel 8750 1350 2    50   Input ~ 0
+SOLAR_MISO
+Text GLabel 8750 1450 2    50   Input ~ 0
+SOLAR_MOSI
+Text GLabel 8750 1550 2    50   Input ~ 0
+SOLAR_CS0
+Text GLabel 8750 1650 2    50   Input ~ 0
+SOLAR_CS1
 $EndSCHEMATC

Commit message: Annotate and begin adding footprints
Parts:
- C37, C38, C39, C40, C41, C42: renamed from C?; footprint (none) -> Capacitor_SMD:C_0805_2012Metric
- H13, H14, H15, H16: renamed from H?; footprint (none) -> MountingHole:MountingHole_2.7mm_M2.5_DIN965_Pad
- J10, J11, J12, J5, J6, J7, J8, J9: renamed from J?; footprint (none) -> Connector_Hirose:Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
- R74, R75, R76, R77, R79, R80: renamed from R?; footprint (none) -> Resistor_SMD:R_0805_2012Metric
- SW3: renamed from SW?; footprint (none) -> Connector_Hirose:Hirose_DF13-02P-1.25DSA_1x02_P1.25mm_Vertical
- gave numbers to parts that had none: 27
